*** SPICE deck for cell Simulacion_Matrix_4096{lay} from library pixel
*** Created on lun ene 20, 2020 12:32:13
*** Last revised on lun ene 20, 2020 15:48:13
*** Written on lun ene 20, 2020 15:48:16 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** SUBCIRCUIT pixel__pixelv3 FROM CELL pixelv3{lay}
.SUBCKT pixel__pixelv3 FD gnd_pix out reset select vdd_f vdd_reset
Mnmos@1 net@90 FD#1nmos@1_poly-right vdd_f gnd_pix NMOS L=0.6U W=3U AS=4.95P AD=1.688P PS=9.3U PD=4.65U
Mnmos@2 out select#2nmos@2_poly-left net@90 gnd_pix NMOS L=0.6U W=3U AS=1.688P AD=4.95P PS=4.65U PD=9.3U
Mnmos@3 vdd_reset reset#0nmos@3_poly-left FD gnd_pix NMOS L=0.6U W=3U AS=9.45P AD=4.95P PS=18.3U PD=9.3U
** Extracted Parasitic Capacitors ***
C0 out 0 1.427fF
C1 FD 0 3.614fF
C2 reset 0 0.973fF
C3 select 0 3.169fF
C4 select#2nmos@2_poly-left 0 0.134fF
C5 FD#2pin@50_polysilicon-1 0 0.141fF
C6 reset#1pin@103_polysilicon-1 0 0.284fF
C7 select#1pin@124_polysilicon-1 0 0.339fF
** Extracted Parasitic Resistors ***
R0 FD#1nmos@1_poly-right FD#1nmos@1_poly-right##0 6.975
R1 FD#1nmos@1_poly-right##0 FD#2pin@50_polysilicon-1 6.975
R2 FD FD#2pin@50_polysilicon-1 4.65
R3 reset#0nmos@3_poly-left reset#1pin@103_polysilicon-1 7.75
R4 select select#1pin@124_polysilicon-1 4.96
R5 select#2nmos@2_poly-left select#2nmos@2_poly-left##0 8.783
C8 select#2nmos@2_poly-left##0 0 0.134fF
R6 select#2nmos@2_poly-left##0 select#2nmos@2_poly-left##1 8.783
C9 select#2nmos@2_poly-left##1 0 0.134fF
R7 select#2nmos@2_poly-left##1 select#1pin@124_polysilicon-1 8.783
R8 reset reset#1pin@103_polysilicon-1 4.96
.ENDS pixel__pixelv3

*** SUBCIRCUIT pixel__Matrix_4 FROM CELL Matrix_4{lay}
.SUBCKT pixel__Matrix_4 gnd_0 gnd_1 out out_1 reset reset_1 select select_1 vdd_0 vdd_1 vdd_reset vdd_reset_1
Xpixelv3@11 pixelv3@11_FD gnd_0 out reset_1 select_1 vdd_1 vdd_reset_1 pixel__pixelv3
Xpixelv3@15 pixelv3@15_FD gnd_1 out_1 reset_1 select_1 vdd_1 vdd_reset_1 pixel__pixelv3
Xpixelv3@16 pixelv3@16_FD gnd_0 out reset select vdd_0 vdd_reset pixel__pixelv3
Xpixelv3@17 pixelv3@17_FD gnd_1 out_1 reset select vdd_0 vdd_reset pixel__pixelv3
** Extracted Parasitic Capacitors ***
C0 out 0 5.598fF
C1 reset_1 0 4.439fF
C2 select_1 0 4.439fF
C3 out_1 0 5.598fF
C4 reset 0 4.439fF
C5 select 0 4.439fF
** Extracted Parasitic Resistors ***
.ENDS pixel__Matrix_4

*** SUBCIRCUIT pixel__Matrix_16 FROM CELL Matrix_16{lay}
.SUBCKT pixel__Matrix_16 gnd out_0 out_1 out_2 out_3 reset_0 reset_1 reset_2 reset_3 select_0 select_1 select_2 select_3 vdd vdd_reset
XMatrix_4@4 gnd gnd out_0 out_1 reset_2 reset_3 select_2 select_3 vdd vdd vdd_reset vdd_reset pixel__Matrix_4
XMatrix_4@5 gnd gnd out_2 out_3 reset_2 reset_3 select_2 select_3 vdd vdd vdd_reset vdd_reset pixel__Matrix_4
XMatrix_4@6 gnd gnd out_0 out_1 reset_0 reset_1 select_0 select_1 vdd vdd vdd_reset vdd_reset pixel__Matrix_4
XMatrix_4@7 gnd gnd out_2 out_3 reset_0 reset_1 select_0 select_1 vdd vdd vdd_reset vdd_reset pixel__Matrix_4
** Extracted Parasitic Capacitors ***
C0 out_0 0 11.196fF
C1 out_1 0 11.196fF
C2 reset_2 0 8.923fF
C3 reset_3 0 8.923fF
C4 select_2 0 8.923fF
C5 select_3 0 8.923fF
C6 out_2 0 11.196fF
C7 out_3 0 11.196fF
C8 reset_0 0 8.879fF
C9 reset_1 0 8.879fF
C10 select_0 0 8.879fF
C11 select_1 0 8.879fF
** Extracted Parasitic Resistors ***
.ENDS pixel__Matrix_16

*** SUBCIRCUIT pixel__Matrix_64 FROM CELL Matrix_64{lay}
.SUBCKT pixel__Matrix_64 gnd out_0 out_1 out_2 out_3 out_4 out_5 out_6 out_7 reset_0 reset_1 reset_2 reset_3 reset_4 reset_5 reset_6 reset_7 select_0 select_1 select_2 select_3 select_4 select_5 select_6 select_7 vdd vdd_reset
XMatrix_1@0 gnd out_0 out_1 out_2 out_3 reset_4 reset_5 reset_6 reset_7 select_4 select_5 select_6 select_7 vdd vdd_reset pixel__Matrix_16
XMatrix_1@1 gnd out_4 out_5 out_6 out_7 reset_4#0Matrix_1@1_reset_0 reset_5#0Matrix_1@1_reset_1 reset_6#0Matrix_1@1_reset_2 reset_7#0Matrix_1@1_reset_3 select_4#0Matrix_1@1_select_0 select_5#0Matrix_1@1_select_1 select_6#0Matrix_1@1_select_2 select_7#0Matrix_1@1_select_3 vdd vdd_reset pixel__Matrix_16
XMatrix_1@2 gnd out_0 out_1 out_2 out_3 reset_0 reset_1 reset_2 reset_3 select_0 select_1 select_2 select_3 vdd vdd_reset pixel__Matrix_16
XMatrix_1@3 gnd out_4 out_5 out_6 out_7 reset_0#0Matrix_1@3_reset_0 reset_1#0Matrix_1@3_reset_1 reset_2#0Matrix_1@3_reset_2 reset_3#0Matrix_1@3_reset_3 select_0#0Matrix_1@3_select_0 select_1#0Matrix_1@3_select_1 select_2#0Matrix_1@3_select_2 select_3#0Matrix_1@3_select_3 vdd vdd_reset pixel__Matrix_16
** Extracted Parasitic Capacitors ***
C0 out_0 0 22.392fF
C1 out_1 0 22.392fF
C2 out_2 0 22.392fF
C3 out_3 0 22.392fF
C4 reset_4 0 9.212fF
C5 reset_5 0 9.212fF
C6 reset_6 0 9.212fF
C7 reset_7 0 9.212fF
C8 select_4 0 9.212fF
C9 select_5 0 9.212fF
C10 select_6 0 9.212fF
C11 select_7 0 9.212fF
C12 out_4 0 22.392fF
C13 out_5 0 22.392fF
C14 out_6 0 22.392fF
C15 out_7 0 22.392fF
C16 reset_4#0Matrix_1@1_reset_0 0 9.212fF
C17 reset_5#0Matrix_1@1_reset_1 0 9.212fF
C18 reset_6#0Matrix_1@1_reset_2 0 9.212fF
C19 reset_7#0Matrix_1@1_reset_3 0 9.212fF
C20 select_4#0Matrix_1@1_select_0 0 9.212fF
C21 select_5#0Matrix_1@1_select_1 0 9.212fF
C22 select_6#0Matrix_1@1_select_2 0 9.212fF
C23 select_7#0Matrix_1@1_select_3 0 9.212fF
C24 reset_0 0 9.212fF
C25 reset_1 0 9.212fF
C26 reset_2 0 9.212fF
C27 reset_3 0 9.212fF
C28 select_0 0 9.212fF
C29 select_1 0 9.212fF
C30 select_2 0 9.212fF
C31 select_3 0 9.212fF
C32 reset_0#0Matrix_1@3_reset_0 0 9.212fF
C33 reset_1#0Matrix_1@3_reset_1 0 9.212fF
C34 reset_2#0Matrix_1@3_reset_2 0 9.212fF
C35 reset_3#0Matrix_1@3_reset_3 0 9.212fF
C36 select_0#0Matrix_1@3_select_0 0 9.212fF
C37 select_1#0Matrix_1@3_select_1 0 9.212fF
C38 select_2#0Matrix_1@3_select_2 0 9.212fF
C39 select_3#0Matrix_1@3_select_3 0 9.212fF
** Extracted Parasitic Resistors ***
R0 select_0 select_0#0Matrix_1@3_select_0 4.046
R1 reset_1 reset_1#0Matrix_1@3_reset_1 4.046
R2 select_1 select_1#0Matrix_1@3_select_1 4.046
R3 reset_2 reset_2#0Matrix_1@3_reset_2 4.046
R4 select_2 select_2#0Matrix_1@3_select_2 4.046
R5 reset_3 reset_3#0Matrix_1@3_reset_3 4.046
R6 select_3 select_3#0Matrix_1@3_select_3 4.046
R7 reset_0 reset_0#0Matrix_1@3_reset_0 4.046
R8 reset_4 reset_4#0Matrix_1@1_reset_0 4.046
R9 select_4 select_4#0Matrix_1@1_select_0 4.046
R10 reset_5 reset_5#0Matrix_1@1_reset_1 4.046
R11 select_5 select_5#0Matrix_1@1_select_1 4.046
R12 reset_6 reset_6#0Matrix_1@1_reset_2 4.046
R13 select_6 select_6#0Matrix_1@1_select_2 4.046
R14 reset_7 reset_7#0Matrix_1@1_reset_3 4.046
R15 select_7 select_7#0Matrix_1@1_select_3 4.046
.ENDS pixel__Matrix_64

*** SUBCIRCUIT pixel__Matrix_256 FROM CELL Matrix_256{lay}
.SUBCKT pixel__Matrix_256 gnd out_0 out_1 out_10 out_11 out_12 out_13 out_14 out_15 out_2 out_3 out_4 out_5 out_6 out_7 out_8 out_9 reset_0 reset_1 reset_10 reset_11 reset_12 reset_13 reset_14 reset_15 reset_2 reset_3 reset_4 reset_5 reset_6 reset_7 reset_8 reset_9 select_0 select_1 select_10 select_11 select_12 select_13 select_14 select_15 select_2 select_3 select_4 select_5 select_6 select_7 select_8 select_9 vdd vdd_reset
XMatrix_6@0 gnd out_0 out_1 out_2 out_3 out_4 out_5 out_6 out_7 reset_8 reset_9 reset_10 reset_11 reset_12 reset_13 reset_14 reset_15 select_8 select_9 select_10 select_11 select_12 select_13 select_14 select_15 vdd vdd_reset pixel__Matrix_64
XMatrix_6@1 gnd out_8 out_9 out_10 out_11 out_12 out_13 out_14 out_15 reset_8#0Matrix_6@1_reset_0 reset_9#0Matrix_6@1_reset_1 reset_10#0Matrix_6@1_reset_2 reset_11#0Matrix_6@1_reset_3 reset_12#0Matrix_6@1_reset_4 reset_13#0Matrix_6@1_reset_5 reset_14#0Matrix_6@1_reset_6 reset_15#0Matrix_6@1_reset_7 select_8#0Matrix_6@1_select_0 select_9#0Matrix_6@1_select_1 select_10#0Matrix_6@1_select_2 select_11#0Matrix_6@1_select_3 select_12#0Matrix_6@1_select_4 select_13#0Matrix_6@1_select_5
+select_14#0Matrix_6@1_select_6 select_15#0Matrix_6@1_select_7 vdd vdd_reset pixel__Matrix_64
XMatrix_6@2 gnd out_0#0Matrix_6@2_out_0 out_1#0Matrix_6@2_out_1 out_2#0Matrix_6@2_out_2 out_3#0Matrix_6@2_out_3 out_4#0Matrix_6@2_out_4 out_5#0Matrix_6@2_out_5 out_6#0Matrix_6@2_out_6 out_7#0Matrix_6@2_out_7 reset_0 reset_1 reset_2 reset_3 reset_4 reset_5 reset_6 reset_7 select_0 select_1 select_2 select_3 select_4 select_5 select_6 select_7 vdd vdd_reset pixel__Matrix_64
XMatrix_6@3 gnd out_8#0Matrix_6@3_out_0 out_9#0Matrix_6@3_out_1 out_10#0Matrix_6@3_out_2 out_11#0Matrix_6@3_out_3 out_12#0Matrix_6@3_out_4 out_13#0Matrix_6@3_out_5 out_14#0Matrix_6@3_out_6 out_15#0Matrix_6@3_out_7 reset_0#0Matrix_6@3_reset_0 reset_1#0Matrix_6@3_reset_1 reset_2#0Matrix_6@3_reset_2 reset_3#0Matrix_6@3_reset_3 reset_4#0Matrix_6@3_reset_4 reset_5#0Matrix_6@3_reset_5 reset_6#0Matrix_6@3_reset_6 reset_7#0Matrix_6@3_reset_7 select_0#0Matrix_6@3_select_0 select_1#0Matrix_6@3_select_1
+select_2#0Matrix_6@3_select_2 select_3#0Matrix_6@3_select_3 select_4#0Matrix_6@3_select_4 select_5#0Matrix_6@3_select_5 select_6#0Matrix_6@3_select_6 select_7#0Matrix_6@3_select_7 vdd vdd_reset pixel__Matrix_64
** Extracted Parasitic Capacitors ***
C0 out_0 0 22.749fF
C1 out_1 0 22.749fF
C2 out_2 0 22.749fF
C3 out_3 0 22.749fF
C4 out_4 0 22.749fF
C5 out_5 0 22.749fF
C6 out_6 0 22.749fF
C7 out_7 0 22.749fF
C8 reset_8 0 18.446fF
C9 reset_9 0 18.446fF
C10 reset_10 0 18.446fF
C11 reset_11 0 18.446fF
C12 reset_12 0 18.446fF
C13 reset_13 0 18.446fF
C14 reset_14 0 18.446fF
C15 reset_15 0 18.446fF
C16 select_8 0 18.446fF
C17 select_9 0 18.446fF
C18 select_10 0 18.446fF
C19 select_11 0 18.446fF
C20 select_12 0 18.446fF
C21 select_13 0 18.446fF
C22 select_14 0 18.446fF
C23 select_15 0 18.446fF
C24 out_8 0 22.749fF
C25 out_9 0 22.749fF
C26 out_10 0 22.749fF
C27 out_11 0 22.749fF
C28 out_12 0 22.749fF
C29 out_13 0 22.749fF
C30 out_14 0 22.749fF
C31 out_15 0 22.749fF
C32 reset_8#0Matrix_6@1_reset_0 0 18.446fF
C33 reset_9#0Matrix_6@1_reset_1 0 18.446fF
C34 reset_10#0Matrix_6@1_reset_2 0 18.446fF
C35 reset_11#0Matrix_6@1_reset_3 0 18.446fF
C36 reset_12#0Matrix_6@1_reset_4 0 18.446fF
C37 reset_13#0Matrix_6@1_reset_5 0 18.446fF
C38 reset_14#0Matrix_6@1_reset_6 0 18.446fF
C39 reset_15#0Matrix_6@1_reset_7 0 18.446fF
C40 select_8#0Matrix_6@1_select_0 0 18.446fF
C41 select_9#0Matrix_6@1_select_1 0 18.446fF
C42 select_10#0Matrix_6@1_select_2 0 18.446fF
C43 select_11#0Matrix_6@1_select_3 0 18.446fF
C44 select_12#0Matrix_6@1_select_4 0 18.446fF
C45 select_13#0Matrix_6@1_select_5 0 18.446fF
C46 select_14#0Matrix_6@1_select_6 0 18.446fF
C47 select_15#0Matrix_6@1_select_7 0 18.446fF
C48 out_0#0Matrix_6@2_out_0 0 22.749fF
C49 out_1#0Matrix_6@2_out_1 0 22.749fF
C50 out_2#0Matrix_6@2_out_2 0 22.749fF
C51 out_3#0Matrix_6@2_out_3 0 22.749fF
C52 out_4#0Matrix_6@2_out_4 0 22.749fF
C53 out_5#0Matrix_6@2_out_5 0 22.749fF
C54 out_6#0Matrix_6@2_out_6 0 22.749fF
C55 out_7#0Matrix_6@2_out_7 0 22.749fF
C56 reset_0 0 18.446fF
C57 reset_1 0 18.446fF
C58 reset_2 0 18.446fF
C59 reset_3 0 18.446fF
C60 reset_4 0 18.446fF
C61 reset_5 0 18.446fF
C62 reset_6 0 18.446fF
C63 reset_7 0 18.446fF
C64 select_0 0 18.446fF
C65 select_1 0 18.446fF
C66 select_2 0 18.446fF
C67 select_3 0 18.446fF
C68 select_4 0 18.446fF
C69 select_5 0 18.446fF
C70 select_6 0 18.446fF
C71 select_7 0 18.446fF
C72 out_8#0Matrix_6@3_out_0 0 22.749fF
C73 out_9#0Matrix_6@3_out_1 0 22.749fF
C74 out_10#0Matrix_6@3_out_2 0 22.749fF
C75 out_11#0Matrix_6@3_out_3 0 22.749fF
C76 out_12#0Matrix_6@3_out_4 0 22.749fF
C77 out_13#0Matrix_6@3_out_5 0 22.749fF
C78 out_14#0Matrix_6@3_out_6 0 22.749fF
C79 out_15#0Matrix_6@3_out_7 0 22.749fF
C80 reset_0#0Matrix_6@3_reset_0 0 18.446fF
C81 reset_1#0Matrix_6@3_reset_1 0 18.446fF
C82 reset_2#0Matrix_6@3_reset_2 0 18.446fF
C83 reset_3#0Matrix_6@3_reset_3 0 18.446fF
C84 reset_4#0Matrix_6@3_reset_4 0 18.446fF
C85 reset_5#0Matrix_6@3_reset_5 0 18.446fF
C86 reset_6#0Matrix_6@3_reset_6 0 18.446fF
C87 reset_7#0Matrix_6@3_reset_7 0 18.446fF
C88 select_0#0Matrix_6@3_select_0 0 18.446fF
C89 select_1#0Matrix_6@3_select_1 0 18.446fF
C90 select_2#0Matrix_6@3_select_2 0 18.446fF
C91 select_3#0Matrix_6@3_select_3 0 18.446fF
C92 select_4#0Matrix_6@3_select_4 0 18.446fF
C93 select_5#0Matrix_6@3_select_5 0 18.446fF
C94 select_6#0Matrix_6@3_select_6 0 18.446fF
C95 select_7#0Matrix_6@3_select_7 0 18.446fF
** Extracted Parasitic Resistors ***
R0 select_0 select_0#0Matrix_6@3_select_0 8.102
R1 reset_1 reset_1#0Matrix_6@3_reset_1 8.102
R2 select_1 select_1#0Matrix_6@3_select_1 8.102
R3 reset_2 reset_2#0Matrix_6@3_reset_2 8.102
R4 select_2 select_2#0Matrix_6@3_select_2 8.102
R5 reset_3 reset_3#0Matrix_6@3_reset_3 8.102
R6 select_3 select_3#0Matrix_6@3_select_3 8.102
R7 reset_4 reset_4#0Matrix_6@3_reset_4 8.102
R8 select_4 select_4#0Matrix_6@3_select_4 8.102
R9 reset_5 reset_5#0Matrix_6@3_reset_5 8.102
R10 select_5 select_5#0Matrix_6@3_select_5 8.102
R11 reset_6 reset_6#0Matrix_6@3_reset_6 8.102
R12 select_6 select_6#0Matrix_6@3_select_6 8.102
R13 reset_7 reset_7#0Matrix_6@3_reset_7 8.102
R14 out_0#0Matrix_6@2_out_0 out_0 8.083
R15 out_1#0Matrix_6@2_out_1 out_1 8.083
R16 out_2#0Matrix_6@2_out_2 out_2 8.083
R17 out_3#0Matrix_6@2_out_3 out_3 8.083
R18 out_4#0Matrix_6@2_out_4 out_4 8.083
R19 out_5#0Matrix_6@2_out_5 out_5 8.083
R20 out_6#0Matrix_6@2_out_6 out_6 8.083
R21 out_9#0Matrix_6@3_out_1 out_9 8.083
R22 out_10#0Matrix_6@3_out_2 out_10 8.083
R23 out_11#0Matrix_6@3_out_3 out_11 8.083
R24 out_12#0Matrix_6@3_out_4 out_12 8.083
R25 out_13#0Matrix_6@3_out_5 out_13 8.083
R26 out_14#0Matrix_6@3_out_6 out_14 8.083
R27 out_15#0Matrix_6@3_out_7 out_15 8.083
R28 select_7 select_7#0Matrix_6@3_select_7 8.102
R29 reset_8 reset_8#0Matrix_6@1_reset_0 8.102
R30 out_8#0Matrix_6@3_out_0 out_8 8.083
R31 select_8 select_8#0Matrix_6@1_select_0 8.102
R32 reset_9 reset_9#0Matrix_6@1_reset_1 8.102
R33 select_9 select_9#0Matrix_6@1_select_1 8.102
R34 reset_10 reset_10#0Matrix_6@1_reset_2 8.102
R35 select_10 select_10#0Matrix_6@1_select_2 8.102
R36 reset_11 reset_11#0Matrix_6@1_reset_3 8.102
R37 select_11 select_11#0Matrix_6@1_select_3 8.102
R38 reset_12 reset_12#0Matrix_6@1_reset_4 8.102
R39 select_12 select_12#0Matrix_6@1_select_4 8.102
R40 reset_13 reset_13#0Matrix_6@1_reset_5 8.102
R41 select_13 select_13#0Matrix_6@1_select_5 8.102
R42 reset_14 reset_14#0Matrix_6@1_reset_6 8.102
R43 select_14 select_14#0Matrix_6@1_select_6 8.102
R44 reset_15 reset_15#0Matrix_6@1_reset_7 8.102
R45 select_15 select_15#0Matrix_6@1_select_7 8.102
R46 out_7#0Matrix_6@2_out_7 out_7 8.083
R47 reset_0 reset_0#0Matrix_6@3_reset_0 8.102
.ENDS pixel__Matrix_256

*** SUBCIRCUIT pixel__Matrix_1024 FROM CELL Matrix_1024{lay}
.SUBCKT pixel__Matrix_1024 gnd out_0 out_1 out_10 out_11 out_12 out_13 out_14 out_15 out_16 out_17 out_18 out_19 out_2 out_20 out_21 out_22 out_23 out_24 out_25 out_26 out_27 out_28 out_29 out_3 out_30 out_31 out_4 out_5 out_6 out_7 out_8 out_9 reset_0 reset_1 reset_10 reset_11 reset_12 reset_13 reset_14 reset_15 reset_16 reset_17 reset_18 reset_19 reset_2 reset_20 reset_21 reset_22 reset_23 reset_24 reset_25 reset_26 reset_27 reset_28 reset_29 reset_3 reset_30 reset_31 reset_4 reset_5 reset_6 reset_7
+reset_8 reset_9 select_0 select_1 select_10 select_11 select_12 select_13 select_14 select_15 select_16 select_17 select_18 select_19 select_2 select_20 select_21 select_22 select_23 select_24 select_25 select_26 select_27 select_28 select_29 select_3 select_30 select_31 select_4 select_5 select_6 select_7 select_8 select_9 vdd vdd_reset
XMatrix_2@0 gnd out_0 out_1 out_10 out_11 out_12 out_13 out_14 out_15 out_2 out_3 out_4 out_5 out_6 out_7 out_8 out_9 reset_16 reset_17 reset_26 reset_27 reset_28 reset_29 reset_30 reset_31 reset_18 reset_19 reset_20 reset_21 reset_22 reset_23 reset_24 reset_25 select_16 select_17 select_26 select_27 select_28 select_29 select_30 select_31 select_18 select_19 select_20 select_21 select_22 select_23 select_24 select_25 vdd vdd_reset pixel__Matrix_256
XMatrix_2@1 gnd out_16 out_17 out_26 out_27 out_28 out_29 out_30 out_31 out_18 out_19 out_20 out_21 out_22 out_23 out_24 out_25 reset_16#0Matrix_2@1_reset_0 reset_17#0Matrix_2@1_reset_1 reset_26#0Matrix_2@1_reset_10 reset_27#0Matrix_2@1_reset_11 reset_28#0Matrix_2@1_reset_12 reset_29#0Matrix_2@1_reset_13 reset_30#0Matrix_2@1_reset_14 reset_31#0Matrix_2@1_reset_15 reset_18#0Matrix_2@1_reset_2 reset_19#0Matrix_2@1_reset_3 reset_20#0Matrix_2@1_reset_4 reset_21#0Matrix_2@1_reset_5 reset_22#0Matrix_2@1_reset_6
+reset_23#0Matrix_2@1_reset_7 reset_24#0Matrix_2@1_reset_8 reset_25#0Matrix_2@1_reset_9 select_16#0Matrix_2@1_select_0 select_17#0Matrix_2@1_select_1 select_26#0Matrix_2@1_select_10 select_27#0Matrix_2@1_select_11 select_28#0Matrix_2@1_select_12 select_29#0Matrix_2@1_select_13 select_30#0Matrix_2@1_select_14 select_31#0Matrix_2@1_select_15 select_18#0Matrix_2@1_select_2 select_19#0Matrix_2@1_select_3 select_20#0Matrix_2@1_select_4 select_21#0Matrix_2@1_select_5 select_22#0Matrix_2@1_select_6
+select_23#0Matrix_2@1_select_7 select_24#0Matrix_2@1_select_8 select_25#0Matrix_2@1_select_9 vdd vdd_reset pixel__Matrix_256
XMatrix_2@2 gnd out_0#0Matrix_2@2_out_0 out_1#0Matrix_2@2_out_1 out_10#0Matrix_2@2_out_10 out_11#0Matrix_2@2_out_11 out_12#0Matrix_2@2_out_12 out_13#0Matrix_2@2_out_13 out_14#0Matrix_2@2_out_14 out_15#0Matrix_2@2_out_15 out_2#0Matrix_2@2_out_2 out_3#0Matrix_2@2_out_3 out_4#0Matrix_2@2_out_4 out_5#0Matrix_2@2_out_5 out_6#0Matrix_2@2_out_6 out_7#0Matrix_2@2_out_7 out_8#0Matrix_2@2_out_8 out_9#0Matrix_2@2_out_9 reset_0 reset_1 reset_10 reset_11 reset_12 reset_13 reset_14 reset_15 reset_2 reset_3 reset_4
+reset_5 reset_6 reset_7 reset_8 reset_9 select_0 select_1 select_10 select_11 select_12 select_13 select_14 select_15 select_2 select_3 select_4 select_5 select_6 select_7 select_8 select_9 vdd vdd_reset pixel__Matrix_256
XMatrix_2@3 gnd out_16#0Matrix_2@3_out_0 out_17#0Matrix_2@3_out_1 out_26#0Matrix_2@3_out_10 out_27#0Matrix_2@3_out_11 out_28#0Matrix_2@3_out_12 out_29#0Matrix_2@3_out_13 out_30#0Matrix_2@3_out_14 out_31#0Matrix_2@3_out_15 out_18#0Matrix_2@3_out_2 out_19#0Matrix_2@3_out_3 out_20#0Matrix_2@3_out_4 out_21#0Matrix_2@3_out_5 out_22#0Matrix_2@3_out_6 out_23#0Matrix_2@3_out_7 out_24#0Matrix_2@3_out_8 out_25#0Matrix_2@3_out_9 reset_0#0Matrix_2@3_reset_0 reset_1#0Matrix_2@3_reset_1 reset_10#0Matrix_2@3_reset_10
+reset_11#0Matrix_2@3_reset_11 reset_12#0Matrix_2@3_reset_12 reset_13#0Matrix_2@3_reset_13 reset_14#0Matrix_2@3_reset_14 reset_15#0Matrix_2@3_reset_15 reset_2#0Matrix_2@3_reset_2 reset_3#0Matrix_2@3_reset_3 reset_4#0Matrix_2@3_reset_4 reset_5#0Matrix_2@3_reset_5 reset_6#0Matrix_2@3_reset_6 reset_7#0Matrix_2@3_reset_7 reset_8#0Matrix_2@3_reset_8 reset_9#0Matrix_2@3_reset_9 select_0#0Matrix_2@3_select_0 select_1#0Matrix_2@3_select_1 select_10#0Matrix_2@3_select_10 select_11#0Matrix_2@3_select_11
+select_12#0Matrix_2@3_select_12 select_13#0Matrix_2@3_select_13 select_14#0Matrix_2@3_select_14 select_15#0Matrix_2@3_select_15 select_2#0Matrix_2@3_select_2 select_3#0Matrix_2@3_select_3 select_4#0Matrix_2@3_select_4 select_5#0Matrix_2@3_select_5 select_6#0Matrix_2@3_select_6 select_7#0Matrix_2@3_select_7 select_8#0Matrix_2@3_select_8 select_9#0Matrix_2@3_select_9 vdd vdd_reset pixel__Matrix_256
** Extracted Parasitic Capacitors ***
C0 out_0 0 30.331fF
C1 out_1 0 30.331fF
C2 out_2 0 30.331fF
C3 out_3 0 30.331fF
C4 out_4 0 30.331fF
C5 out_5 0 30.331fF
C6 out_6 0 30.331fF
C7 out_7 0 30.331fF
C8 out_8 0 30.331fF
C9 out_9 0 30.331fF
C10 out_10 0 30.331fF
C11 out_11 0 30.331fF
C12 out_12 0 30.331fF
C13 out_13 0 30.331fF
C14 out_14 0 30.331fF
C15 out_15 0 30.331fF
C16 reset_16 0 24.579fF
C17 reset_17 0 24.579fF
C18 reset_18 0 24.579fF
C19 reset_19 0 24.579fF
C20 reset_20 0 24.579fF
C21 reset_21 0 24.579fF
C22 reset_22 0 24.579fF
C23 reset_23 0 24.579fF
C24 reset_24 0 24.579fF
C25 reset_25 0 24.579fF
C26 reset_26 0 24.579fF
C27 reset_27 0 24.579fF
C28 reset_28 0 24.579fF
C29 reset_29 0 24.579fF
C30 reset_30 0 24.579fF
C31 reset_31 0 24.579fF
C32 select_16 0 24.579fF
C33 select_17 0 24.579fF
C34 select_18 0 24.579fF
C35 select_19 0 24.579fF
C36 select_20 0 24.579fF
C37 select_21 0 24.579fF
C38 select_22 0 24.579fF
C39 select_23 0 24.579fF
C40 select_24 0 24.579fF
C41 select_25 0 24.579fF
C42 select_26 0 24.579fF
C43 select_27 0 24.579fF
C44 select_28 0 24.579fF
C45 select_29 0 24.579fF
C46 select_30 0 24.579fF
C47 select_31 0 24.579fF
C48 out_16 0 30.331fF
C49 out_17 0 30.331fF
C50 out_18 0 30.331fF
C51 out_19 0 30.331fF
C52 out_20 0 30.331fF
C53 out_21 0 30.331fF
C54 out_22 0 30.331fF
C55 out_23 0 30.331fF
C56 out_24 0 30.331fF
C57 out_25 0 30.331fF
C58 out_26 0 30.331fF
C59 out_27 0 30.331fF
C60 out_28 0 30.331fF
C61 out_29 0 30.331fF
C62 out_30 0 30.331fF
C63 out_31 0 30.331fF
C64 reset_16#0Matrix_2@1_reset_0 0 24.579fF
C65 reset_17#0Matrix_2@1_reset_1 0 24.579fF
C66 reset_18#0Matrix_2@1_reset_2 0 24.579fF
C67 reset_19#0Matrix_2@1_reset_3 0 24.579fF
C68 reset_20#0Matrix_2@1_reset_4 0 24.579fF
C69 reset_21#0Matrix_2@1_reset_5 0 24.579fF
C70 reset_22#0Matrix_2@1_reset_6 0 24.579fF
C71 reset_23#0Matrix_2@1_reset_7 0 24.579fF
C72 reset_24#0Matrix_2@1_reset_8 0 24.579fF
C73 reset_25#0Matrix_2@1_reset_9 0 24.579fF
C74 reset_26#0Matrix_2@1_reset_10 0 24.579fF
C75 reset_27#0Matrix_2@1_reset_11 0 24.579fF
C76 reset_28#0Matrix_2@1_reset_12 0 24.579fF
C77 reset_29#0Matrix_2@1_reset_13 0 24.579fF
C78 reset_30#0Matrix_2@1_reset_14 0 24.579fF
C79 reset_31#0Matrix_2@1_reset_15 0 24.579fF
C80 select_16#0Matrix_2@1_select_0 0 24.579fF
C81 select_17#0Matrix_2@1_select_1 0 24.579fF
C82 select_18#0Matrix_2@1_select_2 0 24.579fF
C83 select_19#0Matrix_2@1_select_3 0 24.579fF
C84 select_20#0Matrix_2@1_select_4 0 24.579fF
C85 select_21#0Matrix_2@1_select_5 0 24.579fF
C86 select_22#0Matrix_2@1_select_6 0 24.579fF
C87 select_23#0Matrix_2@1_select_7 0 24.579fF
C88 select_24#0Matrix_2@1_select_8 0 24.579fF
C89 select_25#0Matrix_2@1_select_9 0 24.579fF
C90 select_26#0Matrix_2@1_select_10 0 24.579fF
C91 select_27#0Matrix_2@1_select_11 0 24.579fF
C92 select_28#0Matrix_2@1_select_12 0 24.579fF
C93 select_29#0Matrix_2@1_select_13 0 24.579fF
C94 select_30#0Matrix_2@1_select_14 0 24.579fF
C95 select_31#0Matrix_2@1_select_15 0 24.579fF
C96 out_0#0Matrix_2@2_out_0 0 30.331fF
C97 out_1#0Matrix_2@2_out_1 0 30.331fF
C98 out_2#0Matrix_2@2_out_2 0 30.331fF
C99 out_3#0Matrix_2@2_out_3 0 30.331fF
C100 out_4#0Matrix_2@2_out_4 0 30.331fF
C101 out_5#0Matrix_2@2_out_5 0 30.331fF
C102 out_6#0Matrix_2@2_out_6 0 30.331fF
C103 out_7#0Matrix_2@2_out_7 0 30.331fF
C104 out_8#0Matrix_2@2_out_8 0 30.331fF
C105 out_9#0Matrix_2@2_out_9 0 30.331fF
C106 out_10#0Matrix_2@2_out_10 0 30.331fF
C107 out_11#0Matrix_2@2_out_11 0 30.331fF
C108 out_12#0Matrix_2@2_out_12 0 30.331fF
C109 out_13#0Matrix_2@2_out_13 0 30.331fF
C110 out_14#0Matrix_2@2_out_14 0 30.331fF
C111 out_15#0Matrix_2@2_out_15 0 30.331fF
C112 reset_0 0 24.579fF
C113 reset_1 0 24.579fF
C114 reset_2 0 24.579fF
C115 reset_3 0 24.579fF
C116 reset_4 0 24.579fF
C117 reset_5 0 24.579fF
C118 reset_6 0 24.579fF
C119 reset_7 0 24.579fF
C120 reset_8 0 24.579fF
C121 reset_9 0 24.579fF
C122 reset_10 0 24.579fF
C123 reset_11 0 24.579fF
C124 reset_12 0 24.579fF
C125 reset_13 0 24.579fF
C126 reset_14 0 24.579fF
C127 reset_15 0 24.579fF
C128 select_0 0 24.579fF
C129 select_1 0 24.579fF
C130 select_2 0 24.579fF
C131 select_3 0 24.579fF
C132 select_4 0 24.579fF
C133 select_5 0 24.579fF
C134 select_6 0 24.579fF
C135 select_7 0 24.579fF
C136 select_8 0 24.579fF
C137 select_9 0 24.579fF
C138 select_10 0 24.579fF
C139 select_11 0 24.579fF
C140 select_12 0 24.579fF
C141 select_13 0 24.579fF
C142 select_14 0 24.579fF
C143 select_15 0 24.579fF
C144 out_16#0Matrix_2@3_out_0 0 30.331fF
C145 out_17#0Matrix_2@3_out_1 0 30.331fF
C146 out_18#0Matrix_2@3_out_2 0 30.331fF
C147 out_19#0Matrix_2@3_out_3 0 30.331fF
C148 out_20#0Matrix_2@3_out_4 0 30.331fF
C149 out_21#0Matrix_2@3_out_5 0 30.331fF
C150 out_22#0Matrix_2@3_out_6 0 30.331fF
C151 out_23#0Matrix_2@3_out_7 0 30.331fF
C152 out_24#0Matrix_2@3_out_8 0 30.331fF
C153 out_25#0Matrix_2@3_out_9 0 30.331fF
C154 out_26#0Matrix_2@3_out_10 0 30.331fF
C155 out_27#0Matrix_2@3_out_11 0 30.331fF
C156 out_28#0Matrix_2@3_out_12 0 30.331fF
C157 out_29#0Matrix_2@3_out_13 0 30.331fF
C158 out_30#0Matrix_2@3_out_14 0 30.331fF
C159 out_31#0Matrix_2@3_out_15 0 30.331fF
C160 reset_0#0Matrix_2@3_reset_0 0 24.579fF
C161 reset_1#0Matrix_2@3_reset_1 0 24.579fF
C162 reset_2#0Matrix_2@3_reset_2 0 24.579fF
C163 reset_3#0Matrix_2@3_reset_3 0 24.579fF
C164 reset_4#0Matrix_2@3_reset_4 0 24.579fF
C165 reset_5#0Matrix_2@3_reset_5 0 24.579fF
C166 reset_6#0Matrix_2@3_reset_6 0 24.579fF
C167 reset_7#0Matrix_2@3_reset_7 0 24.579fF
C168 reset_8#0Matrix_2@3_reset_8 0 24.579fF
C169 reset_9#0Matrix_2@3_reset_9 0 24.579fF
C170 reset_10#0Matrix_2@3_reset_10 0 24.579fF
C171 reset_11#0Matrix_2@3_reset_11 0 24.579fF
C172 reset_12#0Matrix_2@3_reset_12 0 24.579fF
C173 reset_13#0Matrix_2@3_reset_13 0 24.579fF
C174 reset_14#0Matrix_2@3_reset_14 0 24.579fF
C175 reset_15#0Matrix_2@3_reset_15 0 24.579fF
C176 select_0#0Matrix_2@3_select_0 0 24.579fF
C177 select_1#0Matrix_2@3_select_1 0 24.579fF
C178 select_2#0Matrix_2@3_select_2 0 24.579fF
C179 select_3#0Matrix_2@3_select_3 0 24.579fF
C180 select_4#0Matrix_2@3_select_4 0 24.579fF
C181 select_5#0Matrix_2@3_select_5 0 24.579fF
C182 select_6#0Matrix_2@3_select_6 0 24.579fF
C183 select_7#0Matrix_2@3_select_7 0 24.579fF
C184 select_8#0Matrix_2@3_select_8 0 24.579fF
C185 select_9#0Matrix_2@3_select_9 0 24.579fF
C186 select_10#0Matrix_2@3_select_10 0 24.579fF
C187 select_11#0Matrix_2@3_select_11 0 24.579fF
C188 select_12#0Matrix_2@3_select_12 0 24.579fF
C189 select_13#0Matrix_2@3_select_13 0 24.579fF
C190 select_14#0Matrix_2@3_select_14 0 24.579fF
C191 select_15#0Matrix_2@3_select_15 0 24.579fF
** Extracted Parasitic Resistors ***
R0 reset_0 reset_0##0 8.097
C192 reset_0##0 0 24.579fF
R1 reset_0##0 reset_0#0Matrix_2@3_reset_0 8.097
R2 select_0 select_0##0 8.097
C193 select_0##0 0 24.579fF
R3 select_0##0 select_0#0Matrix_2@3_select_0 8.097
R4 reset_1 reset_1##0 8.097
C194 reset_1##0 0 24.579fF
R5 reset_1##0 reset_1#0Matrix_2@3_reset_1 8.097
R6 select_1 select_1##0 8.097
C195 select_1##0 0 24.579fF
R7 select_1##0 select_1#0Matrix_2@3_select_1 8.097
R8 reset_2 reset_2##0 8.097
C196 reset_2##0 0 24.579fF
R9 reset_2##0 reset_2#0Matrix_2@3_reset_2 8.097
R10 select_2 select_2##0 8.097
C197 select_2##0 0 24.579fF
R11 select_2##0 select_2#0Matrix_2@3_select_2 8.097
R12 reset_3 reset_3##0 8.097
C198 reset_3##0 0 24.579fF
R13 reset_3##0 reset_3#0Matrix_2@3_reset_3 8.097
R14 select_3 select_3##0 8.097
C199 select_3##0 0 24.579fF
R15 select_3##0 select_3#0Matrix_2@3_select_3 8.097
R16 reset_4 reset_4##0 8.097
C200 reset_4##0 0 24.579fF
R17 reset_4##0 reset_4#0Matrix_2@3_reset_4 8.097
R18 select_4 select_4##0 8.097
C201 select_4##0 0 24.579fF
R19 select_4##0 select_4#0Matrix_2@3_select_4 8.097
R20 reset_5 reset_5##0 8.097
C202 reset_5##0 0 24.579fF
R21 reset_5##0 reset_5#0Matrix_2@3_reset_5 8.097
R22 select_5 select_5##0 8.097
C203 select_5##0 0 24.579fF
R23 select_5##0 select_5#0Matrix_2@3_select_5 8.097
R24 reset_6 reset_6##0 8.097
C204 reset_6##0 0 24.579fF
R25 reset_6##0 reset_6#0Matrix_2@3_reset_6 8.097
R26 select_6 select_6##0 8.097
C205 select_6##0 0 24.579fF
R27 select_6##0 select_6#0Matrix_2@3_select_6 8.097
R28 reset_7 reset_7##0 8.097
C206 reset_7##0 0 24.579fF
R29 reset_7##0 reset_7#0Matrix_2@3_reset_7 8.097
R30 select_7 select_7##0 8.097
C207 select_7##0 0 24.579fF
R31 select_7##0 select_7#0Matrix_2@3_select_7 8.097
R32 reset_8 reset_8##0 8.097
C208 reset_8##0 0 24.579fF
R33 reset_8##0 reset_8#0Matrix_2@3_reset_8 8.097
R34 select_8 select_8##0 8.097
C209 select_8##0 0 24.579fF
R35 select_8##0 select_8#0Matrix_2@3_select_8 8.097
R36 reset_9 reset_9##0 8.097
C210 reset_9##0 0 24.579fF
R37 reset_9##0 reset_9#0Matrix_2@3_reset_9 8.097
R38 select_9 select_9##0 8.097
C211 select_9##0 0 24.579fF
R39 select_9##0 select_9#0Matrix_2@3_select_9 8.097
R40 reset_10 reset_10##0 8.097
C212 reset_10##0 0 24.579fF
R41 reset_10##0 reset_10#0Matrix_2@3_reset_10 8.097
R42 select_10 select_10##0 8.097
C213 select_10##0 0 24.579fF
R43 select_10##0 select_10#0Matrix_2@3_select_10 8.097
R44 reset_11 reset_11##0 8.097
C214 reset_11##0 0 24.579fF
R45 reset_11##0 reset_11#0Matrix_2@3_reset_11 8.097
R46 select_11 select_11##0 8.097
C215 select_11##0 0 24.579fF
R47 select_11##0 select_11#0Matrix_2@3_select_11 8.097
R48 reset_12 reset_12##0 8.097
C216 reset_12##0 0 24.579fF
R49 reset_12##0 reset_12#0Matrix_2@3_reset_12 8.097
R50 select_12 select_12##0 8.097
C217 select_12##0 0 24.579fF
R51 select_12##0 select_12#0Matrix_2@3_select_12 8.097
R52 reset_13 reset_13##0 8.097
C218 reset_13##0 0 24.579fF
R53 reset_13##0 reset_13#0Matrix_2@3_reset_13 8.097
R54 select_13 select_13##0 8.097
C219 select_13##0 0 24.579fF
R55 select_13##0 select_13#0Matrix_2@3_select_13 8.097
R56 reset_14 reset_14##0 8.097
C220 reset_14##0 0 24.579fF
R57 reset_14##0 reset_14#0Matrix_2@3_reset_14 8.097
R58 select_14 select_14##0 8.097
C221 select_14##0 0 24.579fF
R59 select_14##0 select_14#0Matrix_2@3_select_14 8.097
R60 reset_15 reset_15##0 8.097
C222 reset_15##0 0 24.579fF
R61 reset_15##0 reset_15#0Matrix_2@3_reset_15 8.097
R62 select_15 select_15##0 8.097
C223 select_15##0 0 24.579fF
R63 select_15##0 select_15#0Matrix_2@3_select_15 8.097
R64 reset_16 reset_16##0 8.097
C224 reset_16##0 0 24.579fF
R65 reset_16##0 reset_16#0Matrix_2@1_reset_0 8.097
R66 select_16 select_16##0 8.097
C225 select_16##0 0 24.579fF
R67 select_16##0 select_16#0Matrix_2@1_select_0 8.097
R68 reset_17 reset_17##0 8.097
C226 reset_17##0 0 24.579fF
R69 reset_17##0 reset_17#0Matrix_2@1_reset_1 8.097
R70 select_17 select_17##0 8.097
C227 select_17##0 0 24.579fF
R71 select_17##0 select_17#0Matrix_2@1_select_1 8.097
R72 reset_18 reset_18##0 8.097
C228 reset_18##0 0 24.579fF
R73 reset_18##0 reset_18#0Matrix_2@1_reset_2 8.097
R74 select_18 select_18##0 8.097
C229 select_18##0 0 24.579fF
R75 select_18##0 select_18#0Matrix_2@1_select_2 8.097
R76 reset_19 reset_19##0 8.097
C230 reset_19##0 0 24.579fF
R77 reset_19##0 reset_19#0Matrix_2@1_reset_3 8.097
R78 select_19 select_19##0 8.097
C231 select_19##0 0 24.579fF
R79 select_19##0 select_19#0Matrix_2@1_select_3 8.097
R80 reset_20 reset_20##0 8.097
C232 reset_20##0 0 24.579fF
R81 reset_20##0 reset_20#0Matrix_2@1_reset_4 8.097
R82 select_20 select_20##0 8.097
C233 select_20##0 0 24.579fF
R83 select_20##0 select_20#0Matrix_2@1_select_4 8.097
R84 reset_21 reset_21##0 8.097
C234 reset_21##0 0 24.579fF
R85 reset_21##0 reset_21#0Matrix_2@1_reset_5 8.097
R86 select_21 select_21##0 8.097
C235 select_21##0 0 24.579fF
R87 select_21##0 select_21#0Matrix_2@1_select_5 8.097
R88 reset_22 reset_22##0 8.097
C236 reset_22##0 0 24.579fF
R89 reset_22##0 reset_22#0Matrix_2@1_reset_6 8.097
R90 select_22 select_22##0 8.097
C237 select_22##0 0 24.579fF
R91 select_22##0 select_22#0Matrix_2@1_select_6 8.097
R92 reset_23 reset_23##0 8.097
C238 reset_23##0 0 24.579fF
R93 reset_23##0 reset_23#0Matrix_2@1_reset_7 8.097
R94 select_23 select_23##0 8.097
C239 select_23##0 0 24.579fF
R95 select_23##0 select_23#0Matrix_2@1_select_7 8.097
R96 reset_24 reset_24##0 8.097
C240 reset_24##0 0 24.579fF
R97 reset_24##0 reset_24#0Matrix_2@1_reset_8 8.097
R98 select_24 select_24##0 8.097
C241 select_24##0 0 24.579fF
R99 select_24##0 select_24#0Matrix_2@1_select_8 8.097
R100 reset_25 reset_25##0 8.097
C242 reset_25##0 0 24.579fF
R101 reset_25##0 reset_25#0Matrix_2@1_reset_9 8.097
R102 select_25 select_25##0 8.097
C243 select_25##0 0 24.579fF
R103 select_25##0 select_25#0Matrix_2@1_select_9 8.097
R104 reset_26 reset_26##0 8.097
C244 reset_26##0 0 24.579fF
R105 reset_26##0 reset_26#0Matrix_2@1_reset_10 8.097
R106 select_26 select_26##0 8.097
C245 select_26##0 0 24.579fF
R107 select_26##0 select_26#0Matrix_2@1_select_10 8.097
R108 reset_27 reset_27##0 8.097
C246 reset_27##0 0 24.579fF
R109 reset_27##0 reset_27#0Matrix_2@1_reset_11 8.097
R110 select_27 select_27##0 8.097
C247 select_27##0 0 24.579fF
R111 select_27##0 select_27#0Matrix_2@1_select_11 8.097
R112 reset_28 reset_28##0 8.097
C248 reset_28##0 0 24.579fF
R113 reset_28##0 reset_28#0Matrix_2@1_reset_12 8.097
R114 select_28 select_28##0 8.097
C249 select_28##0 0 24.579fF
R115 select_28##0 select_28#0Matrix_2@1_select_12 8.097
R116 reset_29 reset_29##0 8.097
C250 reset_29##0 0 24.579fF
R117 reset_29##0 reset_29#0Matrix_2@1_reset_13 8.097
R118 select_29 select_29##0 8.097
C251 select_29##0 0 24.579fF
R119 select_29##0 select_29#0Matrix_2@1_select_13 8.097
R120 reset_30 reset_30##0 8.097
C252 reset_30##0 0 24.579fF
R121 reset_30##0 reset_30#0Matrix_2@1_reset_14 8.097
R122 select_30 select_30##0 8.097
C253 select_30##0 0 24.579fF
R123 select_30##0 select_30#0Matrix_2@1_select_14 8.097
R124 select_31 select_31##0 8.097
C254 select_31##0 0 24.579fF
R125 select_31##0 select_31#0Matrix_2@1_select_15 8.097
R126 reset_31 reset_31##0 8.097
C255 reset_31##0 0 24.579fF
R127 reset_31##0 reset_31#0Matrix_2@1_reset_15 8.097
R128 out_0#0Matrix_2@2_out_0 out_0#0Matrix_2@2_out_0##0 8.083
C256 out_0#0Matrix_2@2_out_0##0 0 30.331fF
R129 out_0#0Matrix_2@2_out_0##0 out_0 8.083
R130 out_1#0Matrix_2@2_out_1 out_1#0Matrix_2@2_out_1##0 8.083
C257 out_1#0Matrix_2@2_out_1##0 0 30.331fF
R131 out_1#0Matrix_2@2_out_1##0 out_1 8.083
R132 out_2#0Matrix_2@2_out_2 out_2#0Matrix_2@2_out_2##0 8.083
C258 out_2#0Matrix_2@2_out_2##0 0 30.331fF
R133 out_2#0Matrix_2@2_out_2##0 out_2 8.083
R134 out_3 out_3##0 8.083
C259 out_3##0 0 30.331fF
R135 out_3##0 out_3#0Matrix_2@2_out_3 8.083
R136 out_4#0Matrix_2@2_out_4 out_4#0Matrix_2@2_out_4##0 8.083
C260 out_4#0Matrix_2@2_out_4##0 0 30.331fF
R137 out_4#0Matrix_2@2_out_4##0 out_4 8.083
R138 out_5 out_5##0 8.083
C261 out_5##0 0 30.331fF
R139 out_5##0 out_5#0Matrix_2@2_out_5 8.083
R140 out_6 out_6##0 8.083
C262 out_6##0 0 30.331fF
R141 out_6##0 out_6#0Matrix_2@2_out_6 8.083
R142 out_7 out_7##0 8.083
C263 out_7##0 0 30.331fF
R143 out_7##0 out_7#0Matrix_2@2_out_7 8.083
R144 out_8 out_8##0 8.083
C264 out_8##0 0 30.331fF
R145 out_8##0 out_8#0Matrix_2@2_out_8 8.083
R146 out_9 out_9##0 8.083
C265 out_9##0 0 30.331fF
R147 out_9##0 out_9#0Matrix_2@2_out_9 8.083
R148 out_10#0Matrix_2@2_out_10 out_10#0Matrix_2@2_out_10##0 8.083
C266 out_10#0Matrix_2@2_out_10##0 0 30.331fF
R149 out_10#0Matrix_2@2_out_10##0 out_10 8.083
R150 out_11 out_11##0 8.083
C267 out_11##0 0 30.331fF
R151 out_11##0 out_11#0Matrix_2@2_out_11 8.083
R152 out_12#0Matrix_2@2_out_12 out_12#0Matrix_2@2_out_12##0 8.083
C268 out_12#0Matrix_2@2_out_12##0 0 30.331fF
R153 out_12#0Matrix_2@2_out_12##0 out_12 8.083
R154 out_13#0Matrix_2@2_out_13 out_13#0Matrix_2@2_out_13##0 8.083
C269 out_13#0Matrix_2@2_out_13##0 0 30.331fF
R155 out_13#0Matrix_2@2_out_13##0 out_13 8.083
R156 out_14 out_14##0 8.083
C270 out_14##0 0 30.331fF
R157 out_14##0 out_14#0Matrix_2@2_out_14 8.083
R158 out_15#0Matrix_2@2_out_15 out_15#0Matrix_2@2_out_15##0 8.083
C271 out_15#0Matrix_2@2_out_15##0 0 30.331fF
R159 out_15#0Matrix_2@2_out_15##0 out_15 8.083
R160 out_16#0Matrix_2@3_out_0 out_16#0Matrix_2@3_out_0##0 8.083
C272 out_16#0Matrix_2@3_out_0##0 0 30.331fF
R161 out_16#0Matrix_2@3_out_0##0 out_16 8.083
R162 out_17#0Matrix_2@3_out_1 out_17#0Matrix_2@3_out_1##0 8.083
C273 out_17#0Matrix_2@3_out_1##0 0 30.331fF
R163 out_17#0Matrix_2@3_out_1##0 out_17 8.083
R164 out_18 out_18##0 8.083
C274 out_18##0 0 30.331fF
R165 out_18##0 out_18#0Matrix_2@3_out_2 8.083
R166 out_19#0Matrix_2@3_out_3 out_19#0Matrix_2@3_out_3##0 8.083
C275 out_19#0Matrix_2@3_out_3##0 0 30.331fF
R167 out_19#0Matrix_2@3_out_3##0 out_19 8.083
R168 out_20 out_20##0 8.083
C276 out_20##0 0 30.331fF
R169 out_20##0 out_20#0Matrix_2@3_out_4 8.083
R170 out_21#0Matrix_2@3_out_5 out_21#0Matrix_2@3_out_5##0 8.083
C277 out_21#0Matrix_2@3_out_5##0 0 30.331fF
R171 out_21#0Matrix_2@3_out_5##0 out_21 8.083
R172 out_22 out_22##0 8.083
C278 out_22##0 0 30.331fF
R173 out_22##0 out_22#0Matrix_2@3_out_6 8.083
R174 out_23#0Matrix_2@3_out_7 out_23#0Matrix_2@3_out_7##0 8.083
C279 out_23#0Matrix_2@3_out_7##0 0 30.331fF
R175 out_23#0Matrix_2@3_out_7##0 out_23 8.083
R176 out_24 out_24##0 8.083
C280 out_24##0 0 30.331fF
R177 out_24##0 out_24#0Matrix_2@3_out_8 8.083
R178 out_25#0Matrix_2@3_out_9 out_25#0Matrix_2@3_out_9##0 8.083
C281 out_25#0Matrix_2@3_out_9##0 0 30.331fF
R179 out_25#0Matrix_2@3_out_9##0 out_25 8.083
R180 out_26#0Matrix_2@3_out_10 out_26#0Matrix_2@3_out_10##0 8.083
C282 out_26#0Matrix_2@3_out_10##0 0 30.331fF
R181 out_26#0Matrix_2@3_out_10##0 out_26 8.083
R182 out_27 out_27##0 8.083
C283 out_27##0 0 30.331fF
R183 out_27##0 out_27#0Matrix_2@3_out_11 8.083
R184 out_28#0Matrix_2@3_out_12 out_28#0Matrix_2@3_out_12##0 8.083
C284 out_28#0Matrix_2@3_out_12##0 0 30.331fF
R185 out_28#0Matrix_2@3_out_12##0 out_28 8.083
R186 out_29 out_29##0 8.083
C285 out_29##0 0 30.331fF
R187 out_29##0 out_29#0Matrix_2@3_out_13 8.083
R188 out_30#0Matrix_2@3_out_14 out_30#0Matrix_2@3_out_14##0 8.083
C286 out_30#0Matrix_2@3_out_14##0 0 30.331fF
R189 out_30#0Matrix_2@3_out_14##0 out_30 8.083
R190 out_31 out_31##0 8.083
C287 out_31##0 0 30.331fF
R191 out_31##0 out_31#0Matrix_2@3_out_15 8.083
.ENDS pixel__Matrix_1024

*** TOP LEVEL CELL: Simulacion_Matrix_4096{lay}
XMatrix_1@0 gnd out_0 out_1 out_10 out_11 out_12 out_13 out_14 out_15 out_16 out_17 out_18 out_19 out_2 out_20 out_21 out_22 out_23 out_24 out_25 out_26 out_27 out_28 out_29 out_3 out_30 out_31 out_4 out_5 out_6 out_7 out_8 out_9 reset_32 reset_33 reset_42 reset_43 reset_44 reset_45 reset_46 reset_47 reset_48 reset_49 reset_50 reset_51 reset_34 reset_52 reset_53 reset_54 reset_55 reset_56 reset_57 reset_58 reset_59 reset_60 reset_61 reset_35 reset_62 reset_63 reset_36 reset_37 reset_38 reset_39 reset_40
+reset_41 select_32 select_33 select_42 select_43 select_44 select_45 select_46 select_47 select_48 select_49 select_50 select_51 select_34 select_52 select_53 select_54 select_55 select_56 select_57 select_58 select_59 select_60 select_61 select_35 select_62 select_63 select_36 select_37 select_38 select_39 select_40 select_41 vdd vdd_reset pixel__Matrix_1024
XMatrix_1@1 gnd out_32 out_33 out_42 out_43 out_44 out_45 out_46 out_47 out_48 out_49 out_50 out_51 out_34 out_52 out_53 out_54 out_55 out_56 out_57 out_58 out_59 out_60 out_61 out_35 out_62 out_63 out_36 out_37 out_38 out_39 out_40 out_41 reset_32#0Matrix_1@1_reset_0 reset_33#0Matrix_1@1_reset_1 reset_42#0Matrix_1@1_reset_10 reset_43#0Matrix_1@1_reset_11 reset_44#0Matrix_1@1_reset_12 reset_45#0Matrix_1@1_reset_13 reset_46#0Matrix_1@1_reset_14 reset_47#0Matrix_1@1_reset_15 reset_48#0Matrix_1@1_reset_16
+reset_49#0Matrix_1@1_reset_17 reset_50#0Matrix_1@1_reset_18 reset_51#0Matrix_1@1_reset_19 reset_34#0Matrix_1@1_reset_2 reset_52#0Matrix_1@1_reset_20 reset_53#0Matrix_1@1_reset_21 reset_54#0Matrix_1@1_reset_22 reset_55#0Matrix_1@1_reset_23 reset_56#0Matrix_1@1_reset_24 reset_57#0Matrix_1@1_reset_25 reset_58#0Matrix_1@1_reset_26 reset_59#0Matrix_1@1_reset_27 reset_60#0Matrix_1@1_reset_28 reset_61#0Matrix_1@1_reset_29 reset_35#0Matrix_1@1_reset_3 reset_62#0Matrix_1@1_reset_30 reset_63#0Matrix_1@1_reset_31
+reset_36#0Matrix_1@1_reset_4 reset_37#0Matrix_1@1_reset_5 reset_38#0Matrix_1@1_reset_6 reset_39#0Matrix_1@1_reset_7 reset_40#0Matrix_1@1_reset_8 reset_41#0Matrix_1@1_reset_9 select_32#0Matrix_1@1_select_0 select_33#0Matrix_1@1_select_1 select_42#0Matrix_1@1_select_10 select_43#0Matrix_1@1_select_11 select_44#0Matrix_1@1_select_12 select_45#0Matrix_1@1_select_13 select_46#0Matrix_1@1_select_14 select_47#0Matrix_1@1_select_15 select_48#0Matrix_1@1_select_16 select_49#0Matrix_1@1_select_17
+select_50#0Matrix_1@1_select_18 select_51#0Matrix_1@1_select_19 select_34#0Matrix_1@1_select_2 select_52#0Matrix_1@1_select_20 select_53#0Matrix_1@1_select_21 select_54#0Matrix_1@1_select_22 select_55#0Matrix_1@1_select_23 select_56#0Matrix_1@1_select_24 select_57#0Matrix_1@1_select_25 select_58#0Matrix_1@1_select_26 select_59#0Matrix_1@1_select_27 select_60#0Matrix_1@1_select_28 select_61#0Matrix_1@1_select_29 select_35#0Matrix_1@1_select_3 select_62#0Matrix_1@1_select_30 select_63#0Matrix_1@1_select_31
+select_36#0Matrix_1@1_select_4 select_37#0Matrix_1@1_select_5 select_38#0Matrix_1@1_select_6 select_39#0Matrix_1@1_select_7 select_40#0Matrix_1@1_select_8 select_41#0Matrix_1@1_select_9 vdd vdd_reset pixel__Matrix_1024
XMatrix_1@2 gnd out_0#0Matrix_1@2_out_0 out_1#0Matrix_1@2_out_1 out_10#0Matrix_1@2_out_10 out_11#0Matrix_1@2_out_11 out_12#0Matrix_1@2_out_12 out_13#0Matrix_1@2_out_13 out_14#0Matrix_1@2_out_14 out_15#0Matrix_1@2_out_15 out_16#0Matrix_1@2_out_16 out_17#0Matrix_1@2_out_17 out_18#0Matrix_1@2_out_18 out_19#0Matrix_1@2_out_19 out_2#0Matrix_1@2_out_2 out_20#0Matrix_1@2_out_20 out_21#0Matrix_1@2_out_21 out_22#0Matrix_1@2_out_22 out_23#0Matrix_1@2_out_23 out_24#0Matrix_1@2_out_24 out_25#0Matrix_1@2_out_25
+out_26#0Matrix_1@2_out_26 out_27#0Matrix_1@2_out_27 out_28#0Matrix_1@2_out_28 out_29#0Matrix_1@2_out_29 out_3#0Matrix_1@2_out_3 out_30#0Matrix_1@2_out_30 out_31#0Matrix_1@2_out_31 out_4#0Matrix_1@2_out_4 out_5#0Matrix_1@2_out_5 out_6#0Matrix_1@2_out_6 out_7#0Matrix_1@2_out_7 out_8#0Matrix_1@2_out_8 out_9#0Matrix_1@2_out_9 reset_0 reset_1 reset_10 reset_11 reset_12 reset_13 reset_14 reset_15 reset_16 reset_17 reset_18 reset_19 reset_2 reset_20 reset_21 reset_22 reset_23 reset_24 reset_25 reset_26 reset_27
+reset_28 reset_29 reset_3 reset_30 reset_31 reset_4 reset_5 reset_6 reset_7 reset_8 reset_9 select_0 select_1 select_10 select_11 select_12 select_13 select_14 select_15 select_16 select_17 select_18 select_19 select_2 select_20 select_21 select_22 select_23 select_24 select_25 select_26 select_27 select_28 select_29 select_3 select_30 select_31 select_4 select_5 select_6 select_7 select_8 select_9 vdd vdd_reset pixel__Matrix_1024
XMatrix_1@3 gnd out_32#0Matrix_1@3_out_0 out_33#0Matrix_1@3_out_1 out_42#0Matrix_1@3_out_10 out_43#0Matrix_1@3_out_11 out_44#0Matrix_1@3_out_12 out_45#0Matrix_1@3_out_13 out_46#0Matrix_1@3_out_14 out_47#0Matrix_1@3_out_15 out_48#0Matrix_1@3_out_16 out_49#0Matrix_1@3_out_17 out_50#0Matrix_1@3_out_18 out_51#0Matrix_1@3_out_19 out_34#0Matrix_1@3_out_2 out_52#0Matrix_1@3_out_20 out_53#0Matrix_1@3_out_21 out_54#0Matrix_1@3_out_22 out_55#0Matrix_1@3_out_23 out_56#0Matrix_1@3_out_24 out_57#0Matrix_1@3_out_25
+out_58#0Matrix_1@3_out_26 out_59#0Matrix_1@3_out_27 out_60#0Matrix_1@3_out_28 out_61#0Matrix_1@3_out_29 out_35#0Matrix_1@3_out_3 out_62#0Matrix_1@3_out_30 out_63#0Matrix_1@3_out_31 out_36#0Matrix_1@3_out_4 out_37#0Matrix_1@3_out_5 out_38#0Matrix_1@3_out_6 out_39#0Matrix_1@3_out_7 out_40#0Matrix_1@3_out_8 out_41#0Matrix_1@3_out_9 reset_0#0Matrix_1@3_reset_0 reset_1#0Matrix_1@3_reset_1 reset_10#0Matrix_1@3_reset_10 reset_11#0Matrix_1@3_reset_11 reset_12#0Matrix_1@3_reset_12 reset_13#0Matrix_1@3_reset_13
+reset_14#0Matrix_1@3_reset_14 reset_15#0Matrix_1@3_reset_15 reset_16#0Matrix_1@3_reset_16 reset_17#0Matrix_1@3_reset_17 reset_18#0Matrix_1@3_reset_18 reset_19#0Matrix_1@3_reset_19 reset_2#0Matrix_1@3_reset_2 reset_20#0Matrix_1@3_reset_20 reset_21#0Matrix_1@3_reset_21 reset_22#0Matrix_1@3_reset_22 reset_23#0Matrix_1@3_reset_23 reset_24#0Matrix_1@3_reset_24 reset_25#0Matrix_1@3_reset_25 reset_26#0Matrix_1@3_reset_26 reset_27#0Matrix_1@3_reset_27 reset_28#0Matrix_1@3_reset_28 reset_29#0Matrix_1@3_reset_29
+reset_3#0Matrix_1@3_reset_3 reset_30#0Matrix_1@3_reset_30 reset_31#0Matrix_1@3_reset_31 reset_4#0Matrix_1@3_reset_4 reset_5#0Matrix_1@3_reset_5 reset_6#0Matrix_1@3_reset_6 reset_7#0Matrix_1@3_reset_7 reset_8#0Matrix_1@3_reset_8 reset_9#0Matrix_1@3_reset_9 select_0#0Matrix_1@3_select_0 select_1#0Matrix_1@3_select_1 select_10#0Matrix_1@3_select_10 select_11#0Matrix_1@3_select_11 select_12#0Matrix_1@3_select_12 select_13#0Matrix_1@3_select_13 select_14#0Matrix_1@3_select_14 select_15#0Matrix_1@3_select_15
+select_16#0Matrix_1@3_select_16 select_17#0Matrix_1@3_select_17 select_18#0Matrix_1@3_select_18 select_19#0Matrix_1@3_select_19 select_2#0Matrix_1@3_select_2 select_20#0Matrix_1@3_select_20 select_21#0Matrix_1@3_select_21 select_22#0Matrix_1@3_select_22 select_23#0Matrix_1@3_select_23 select_24#0Matrix_1@3_select_24 select_25#0Matrix_1@3_select_25 select_26#0Matrix_1@3_select_26 select_27#0Matrix_1@3_select_27 select_28#0Matrix_1@3_select_28 select_29#0Matrix_1@3_select_29 select_3#0Matrix_1@3_select_3
+select_30#0Matrix_1@3_select_30 select_31#0Matrix_1@3_select_31 select_4#0Matrix_1@3_select_4 select_5#0Matrix_1@3_select_5 select_6#0Matrix_1@3_select_6 select_7#0Matrix_1@3_select_7 select_8#0Matrix_1@3_select_8 select_9#0Matrix_1@3_select_9 vdd vdd_reset pixel__Matrix_1024
Xpixelv3@0 FD gnd out_0#1pixelv3@0_out reset select vdd vdd_reset pixel__pixelv3
** Extracted Parasitic Capacitors ***
C0 out_0 0 81.847fF
C1 out_1 0 36.398fF
C2 out_2 0 36.398fF
C3 out_3 0 36.398fF
C4 out_4 0 36.398fF
C5 out_5 0 36.398fF
C6 out_6 0 36.398fF
C7 out_7 0 36.398fF
C8 out_8 0 36.398fF
C9 out_9 0 36.398fF
C10 out_10 0 36.398fF
C11 out_11 0 36.398fF
C12 out_12 0 36.398fF
C13 out_13 0 36.398fF
C14 out_14 0 36.398fF
C15 out_15 0 36.398fF
C16 out_16 0 36.398fF
C17 out_17 0 36.398fF
C18 out_18 0 36.398fF
C19 out_19 0 36.398fF
C20 out_20 0 36.398fF
C21 out_21 0 36.398fF
C22 out_22 0 36.398fF
C23 out_23 0 36.398fF
C24 out_24 0 36.398fF
C25 out_25 0 36.398fF
C26 out_26 0 36.398fF
C27 out_27 0 36.398fF
C28 out_28 0 36.398fF
C29 out_29 0 36.398fF
C30 out_30 0 36.398fF
C31 out_31 0 36.398fF
C32 reset_32 0 29.504fF
C33 reset_33 0 29.504fF
C34 reset_34 0 29.504fF
C35 reset_35 0 29.504fF
C36 reset_36 0 29.504fF
C37 reset_37 0 29.504fF
C38 reset_38 0 29.504fF
C39 reset_39 0 29.504fF
C40 reset_40 0 29.504fF
C41 reset_41 0 29.504fF
C42 reset_42 0 29.504fF
C43 reset_43 0 29.504fF
C44 reset_44 0 29.504fF
C45 reset_45 0 29.504fF
C46 reset_46 0 29.504fF
C47 reset_47 0 29.504fF
C48 reset_48 0 29.504fF
C49 reset_49 0 29.504fF
C50 reset_50 0 29.504fF
C51 reset_51 0 29.504fF
C52 reset_52 0 29.504fF
C53 reset_53 0 29.504fF
C54 reset_54 0 29.504fF
C55 reset_55 0 29.504fF
C56 reset_56 0 29.504fF
C57 reset_57 0 29.504fF
C58 reset_58 0 29.504fF
C59 reset_59 0 29.504fF
C60 reset_60 0 29.504fF
C61 reset_61 0 29.504fF
C62 reset_62 0 29.504fF
C63 reset_63 0 29.504fF
C64 select_32 0 29.504fF
C65 select_33 0 29.504fF
C66 select_34 0 29.504fF
C67 select_35 0 29.504fF
C68 select_36 0 29.504fF
C69 select_37 0 29.504fF
C70 select_38 0 29.504fF
C71 select_39 0 29.504fF
C72 select_40 0 29.504fF
C73 select_41 0 29.504fF
C74 select_42 0 29.504fF
C75 select_43 0 29.504fF
C76 select_44 0 29.504fF
C77 select_45 0 29.504fF
C78 select_46 0 29.504fF
C79 select_47 0 29.504fF
C80 select_48 0 29.504fF
C81 select_49 0 29.504fF
C82 select_50 0 29.504fF
C83 select_51 0 29.504fF
C84 select_52 0 29.504fF
C85 select_53 0 29.504fF
C86 select_54 0 29.504fF
C87 select_55 0 29.504fF
C88 select_56 0 29.504fF
C89 select_57 0 29.504fF
C90 select_58 0 29.504fF
C91 select_59 0 29.504fF
C92 select_60 0 29.504fF
C93 select_61 0 29.504fF
C94 select_62 0 29.504fF
C95 select_63 0 29.504fF
C96 out_32 0 36.398fF
C97 out_33 0 36.398fF
C98 out_34 0 36.398fF
C99 out_35 0 36.398fF
C100 out_36 0 36.398fF
C101 out_37 0 36.398fF
C102 out_38 0 36.398fF
C103 out_39 0 36.398fF
C104 out_40 0 36.398fF
C105 out_41 0 36.398fF
C106 out_42 0 36.398fF
C107 out_43 0 36.398fF
C108 out_44 0 36.398fF
C109 out_45 0 36.398fF
C110 out_46 0 36.398fF
C111 out_47 0 36.398fF
C112 out_48 0 36.398fF
C113 out_49 0 36.398fF
C114 out_50 0 36.398fF
C115 out_51 0 36.398fF
C116 out_52 0 36.398fF
C117 out_53 0 36.398fF
C118 out_54 0 36.398fF
C119 out_55 0 36.398fF
C120 out_56 0 36.398fF
C121 out_57 0 36.398fF
C122 out_58 0 36.398fF
C123 out_59 0 36.398fF
C124 out_60 0 36.398fF
C125 out_61 0 36.398fF
C126 out_62 0 36.398fF
C127 out_63 0 36.398fF
C128 reset_32#0Matrix_1@1_reset_0 0 29.504fF
C129 reset_33#0Matrix_1@1_reset_1 0 29.504fF
C130 reset_34#0Matrix_1@1_reset_2 0 29.504fF
C131 reset_35#0Matrix_1@1_reset_3 0 29.504fF
C132 reset_36#0Matrix_1@1_reset_4 0 29.504fF
C133 reset_37#0Matrix_1@1_reset_5 0 29.504fF
C134 reset_38#0Matrix_1@1_reset_6 0 29.504fF
C135 reset_39#0Matrix_1@1_reset_7 0 29.504fF
C136 reset_40#0Matrix_1@1_reset_8 0 29.504fF
C137 reset_41#0Matrix_1@1_reset_9 0 29.504fF
C138 reset_42#0Matrix_1@1_reset_10 0 29.504fF
C139 reset_43#0Matrix_1@1_reset_11 0 29.504fF
C140 reset_44#0Matrix_1@1_reset_12 0 29.504fF
C141 reset_45#0Matrix_1@1_reset_13 0 29.504fF
C142 reset_46#0Matrix_1@1_reset_14 0 29.504fF
C143 reset_47#0Matrix_1@1_reset_15 0 29.504fF
C144 reset_48#0Matrix_1@1_reset_16 0 29.504fF
C145 reset_49#0Matrix_1@1_reset_17 0 29.504fF
C146 reset_50#0Matrix_1@1_reset_18 0 29.504fF
C147 reset_51#0Matrix_1@1_reset_19 0 29.504fF
C148 reset_52#0Matrix_1@1_reset_20 0 29.504fF
C149 reset_53#0Matrix_1@1_reset_21 0 29.504fF
C150 reset_54#0Matrix_1@1_reset_22 0 29.504fF
C151 reset_55#0Matrix_1@1_reset_23 0 29.504fF
C152 reset_56#0Matrix_1@1_reset_24 0 29.504fF
C153 reset_57#0Matrix_1@1_reset_25 0 29.504fF
C154 reset_58#0Matrix_1@1_reset_26 0 29.504fF
C155 reset_59#0Matrix_1@1_reset_27 0 29.504fF
C156 reset_60#0Matrix_1@1_reset_28 0 29.504fF
C157 reset_61#0Matrix_1@1_reset_29 0 29.504fF
C158 reset_62#0Matrix_1@1_reset_30 0 29.504fF
C159 reset_63#0Matrix_1@1_reset_31 0 29.504fF
C160 select_32#0Matrix_1@1_select_0 0 29.504fF
C161 select_33#0Matrix_1@1_select_1 0 29.504fF
C162 select_34#0Matrix_1@1_select_2 0 29.504fF
C163 select_35#0Matrix_1@1_select_3 0 29.504fF
C164 select_36#0Matrix_1@1_select_4 0 29.504fF
C165 select_37#0Matrix_1@1_select_5 0 29.504fF
C166 select_38#0Matrix_1@1_select_6 0 29.504fF
C167 select_39#0Matrix_1@1_select_7 0 29.504fF
C168 select_40#0Matrix_1@1_select_8 0 29.504fF
C169 select_41#0Matrix_1@1_select_9 0 29.504fF
C170 select_42#0Matrix_1@1_select_10 0 29.504fF
C171 select_43#0Matrix_1@1_select_11 0 29.504fF
C172 select_44#0Matrix_1@1_select_12 0 29.504fF
C173 select_45#0Matrix_1@1_select_13 0 29.504fF
C174 select_46#0Matrix_1@1_select_14 0 29.504fF
C175 select_47#0Matrix_1@1_select_15 0 29.504fF
C176 select_48#0Matrix_1@1_select_16 0 29.504fF
C177 select_49#0Matrix_1@1_select_17 0 29.504fF
C178 select_50#0Matrix_1@1_select_18 0 29.504fF
C179 select_51#0Matrix_1@1_select_19 0 29.504fF
C180 select_52#0Matrix_1@1_select_20 0 29.504fF
C181 select_53#0Matrix_1@1_select_21 0 29.504fF
C182 select_54#0Matrix_1@1_select_22 0 29.504fF
C183 select_55#0Matrix_1@1_select_23 0 29.504fF
C184 select_56#0Matrix_1@1_select_24 0 29.504fF
C185 select_57#0Matrix_1@1_select_25 0 29.504fF
C186 select_58#0Matrix_1@1_select_26 0 29.504fF
C187 select_59#0Matrix_1@1_select_27 0 29.504fF
C188 select_60#0Matrix_1@1_select_28 0 29.504fF
C189 select_61#0Matrix_1@1_select_29 0 29.504fF
C190 select_62#0Matrix_1@1_select_30 0 29.504fF
C191 select_63#0Matrix_1@1_select_31 0 29.504fF
C192 out_0#0Matrix_1@2_out_0 0 36.398fF
C193 out_1#0Matrix_1@2_out_1 0 36.398fF
C194 out_2#0Matrix_1@2_out_2 0 36.398fF
C195 out_3#0Matrix_1@2_out_3 0 36.398fF
C196 out_4#0Matrix_1@2_out_4 0 36.398fF
C197 out_5#0Matrix_1@2_out_5 0 36.398fF
C198 out_6#0Matrix_1@2_out_6 0 36.398fF
C199 out_7#0Matrix_1@2_out_7 0 36.398fF
C200 out_8#0Matrix_1@2_out_8 0 36.398fF
C201 out_9#0Matrix_1@2_out_9 0 36.398fF
C202 out_10#0Matrix_1@2_out_10 0 36.398fF
C203 out_11#0Matrix_1@2_out_11 0 36.398fF
C204 out_12#0Matrix_1@2_out_12 0 36.398fF
C205 out_13#0Matrix_1@2_out_13 0 36.398fF
C206 out_14#0Matrix_1@2_out_14 0 36.398fF
C207 out_15#0Matrix_1@2_out_15 0 36.398fF
C208 out_16#0Matrix_1@2_out_16 0 36.398fF
C209 out_17#0Matrix_1@2_out_17 0 36.398fF
C210 out_18#0Matrix_1@2_out_18 0 36.398fF
C211 out_19#0Matrix_1@2_out_19 0 36.398fF
C212 out_20#0Matrix_1@2_out_20 0 36.398fF
C213 out_21#0Matrix_1@2_out_21 0 36.398fF
C214 out_22#0Matrix_1@2_out_22 0 36.398fF
C215 out_23#0Matrix_1@2_out_23 0 36.398fF
C216 out_24#0Matrix_1@2_out_24 0 36.398fF
C217 out_25#0Matrix_1@2_out_25 0 36.398fF
C218 out_26#0Matrix_1@2_out_26 0 36.398fF
C219 out_27#0Matrix_1@2_out_27 0 36.398fF
C220 out_28#0Matrix_1@2_out_28 0 36.398fF
C221 out_29#0Matrix_1@2_out_29 0 36.398fF
C222 out_30#0Matrix_1@2_out_30 0 36.398fF
C223 out_31#0Matrix_1@2_out_31 0 36.398fF
C224 reset_0 0 29.504fF
C225 reset_1 0 29.504fF
C226 reset_2 0 29.504fF
C227 reset_3 0 29.504fF
C228 reset_4 0 29.504fF
C229 reset_5 0 29.504fF
C230 reset_6 0 29.504fF
C231 reset_7 0 29.504fF
C232 reset_8 0 29.504fF
C233 reset_9 0 29.504fF
C234 reset_10 0 29.504fF
C235 reset_11 0 29.504fF
C236 reset_12 0 29.504fF
C237 reset_13 0 29.504fF
C238 reset_14 0 29.504fF
C239 reset_15 0 29.504fF
C240 reset_16 0 29.504fF
C241 reset_17 0 29.504fF
C242 reset_18 0 29.504fF
C243 reset_19 0 29.504fF
C244 reset_20 0 29.504fF
C245 reset_21 0 29.504fF
C246 reset_22 0 29.504fF
C247 reset_23 0 29.504fF
C248 reset_24 0 29.504fF
C249 reset_25 0 29.504fF
C250 reset_26 0 29.504fF
C251 reset_27 0 29.504fF
C252 reset_28 0 29.504fF
C253 reset_29 0 29.504fF
C254 reset_30 0 29.504fF
C255 reset_31 0 29.504fF
C256 select_0 0 29.504fF
C257 select_1 0 29.504fF
C258 select_2 0 29.504fF
C259 select_3 0 29.504fF
C260 select_4 0 29.504fF
C261 select_5 0 29.504fF
C262 select_6 0 29.504fF
C263 select_7 0 29.504fF
C264 select_8 0 29.504fF
C265 select_9 0 29.504fF
C266 select_10 0 29.504fF
C267 select_11 0 29.504fF
C268 select_12 0 29.504fF
C269 select_13 0 29.504fF
C270 select_14 0 29.504fF
C271 select_15 0 29.504fF
C272 select_16 0 29.504fF
C273 select_17 0 29.504fF
C274 select_18 0 29.504fF
C275 select_19 0 29.504fF
C276 select_20 0 29.504fF
C277 select_21 0 29.504fF
C278 select_22 0 29.504fF
C279 select_23 0 29.504fF
C280 select_24 0 29.504fF
C281 select_25 0 29.504fF
C282 select_26 0 29.504fF
C283 select_27 0 29.504fF
C284 select_28 0 29.504fF
C285 select_29 0 29.504fF
C286 select_30 0 29.504fF
C287 select_31 0 29.504fF
C288 out_32#0Matrix_1@3_out_0 0 36.398fF
C289 out_33#0Matrix_1@3_out_1 0 36.398fF
C290 out_34#0Matrix_1@3_out_2 0 36.398fF
C291 out_35#0Matrix_1@3_out_3 0 36.398fF
C292 out_36#0Matrix_1@3_out_4 0 36.398fF
C293 out_37#0Matrix_1@3_out_5 0 36.398fF
C294 out_38#0Matrix_1@3_out_6 0 36.398fF
C295 out_39#0Matrix_1@3_out_7 0 36.398fF
C296 out_40#0Matrix_1@3_out_8 0 36.398fF
C297 out_41#0Matrix_1@3_out_9 0 36.398fF
C298 out_42#0Matrix_1@3_out_10 0 36.398fF
C299 out_43#0Matrix_1@3_out_11 0 36.398fF
C300 out_44#0Matrix_1@3_out_12 0 36.398fF
C301 out_45#0Matrix_1@3_out_13 0 36.398fF
C302 out_46#0Matrix_1@3_out_14 0 36.398fF
C303 out_47#0Matrix_1@3_out_15 0 36.398fF
C304 out_48#0Matrix_1@3_out_16 0 36.398fF
C305 out_49#0Matrix_1@3_out_17 0 36.398fF
C306 out_50#0Matrix_1@3_out_18 0 36.398fF
C307 out_51#0Matrix_1@3_out_19 0 36.398fF
C308 out_52#0Matrix_1@3_out_20 0 36.398fF
C309 out_53#0Matrix_1@3_out_21 0 36.398fF
C310 out_54#0Matrix_1@3_out_22 0 36.398fF
C311 out_55#0Matrix_1@3_out_23 0 36.398fF
C312 out_56#0Matrix_1@3_out_24 0 36.398fF
C313 out_57#0Matrix_1@3_out_25 0 36.398fF
C314 out_58#0Matrix_1@3_out_26 0 36.398fF
C315 out_59#0Matrix_1@3_out_27 0 36.398fF
C316 out_60#0Matrix_1@3_out_28 0 36.398fF
C317 out_61#0Matrix_1@3_out_29 0 36.398fF
C318 out_62#0Matrix_1@3_out_30 0 36.398fF
C319 out_63#0Matrix_1@3_out_31 0 36.398fF
C320 reset_0#0Matrix_1@3_reset_0 0 29.504fF
C321 reset_1#0Matrix_1@3_reset_1 0 29.504fF
C322 reset_2#0Matrix_1@3_reset_2 0 29.504fF
C323 reset_3#0Matrix_1@3_reset_3 0 29.504fF
C324 reset_4#0Matrix_1@3_reset_4 0 29.504fF
C325 reset_5#0Matrix_1@3_reset_5 0 29.504fF
C326 reset_6#0Matrix_1@3_reset_6 0 29.504fF
C327 reset_7#0Matrix_1@3_reset_7 0 29.504fF
C328 reset_8#0Matrix_1@3_reset_8 0 29.504fF
C329 reset_9#0Matrix_1@3_reset_9 0 29.504fF
C330 reset_10#0Matrix_1@3_reset_10 0 29.504fF
C331 reset_11#0Matrix_1@3_reset_11 0 29.504fF
C332 reset_12#0Matrix_1@3_reset_12 0 29.504fF
C333 reset_13#0Matrix_1@3_reset_13 0 29.504fF
C334 reset_14#0Matrix_1@3_reset_14 0 29.504fF
C335 reset_15#0Matrix_1@3_reset_15 0 29.504fF
C336 reset_16#0Matrix_1@3_reset_16 0 29.504fF
C337 reset_17#0Matrix_1@3_reset_17 0 29.504fF
C338 reset_18#0Matrix_1@3_reset_18 0 29.504fF
C339 reset_19#0Matrix_1@3_reset_19 0 29.504fF
C340 reset_20#0Matrix_1@3_reset_20 0 29.504fF
C341 reset_21#0Matrix_1@3_reset_21 0 29.504fF
C342 reset_22#0Matrix_1@3_reset_22 0 29.504fF
C343 reset_23#0Matrix_1@3_reset_23 0 29.504fF
C344 reset_24#0Matrix_1@3_reset_24 0 29.504fF
C345 reset_25#0Matrix_1@3_reset_25 0 29.504fF
C346 reset_26#0Matrix_1@3_reset_26 0 29.504fF
C347 reset_27#0Matrix_1@3_reset_27 0 29.504fF
C348 reset_28#0Matrix_1@3_reset_28 0 29.504fF
C349 reset_29#0Matrix_1@3_reset_29 0 29.504fF
C350 reset_30#0Matrix_1@3_reset_30 0 29.504fF
C351 reset_31#0Matrix_1@3_reset_31 0 29.504fF
C352 select_0#0Matrix_1@3_select_0 0 29.504fF
C353 select_1#0Matrix_1@3_select_1 0 29.504fF
C354 select_2#0Matrix_1@3_select_2 0 29.504fF
C355 select_3#0Matrix_1@3_select_3 0 29.504fF
C356 select_4#0Matrix_1@3_select_4 0 29.504fF
C357 select_5#0Matrix_1@3_select_5 0 29.504fF
C358 select_6#0Matrix_1@3_select_6 0 29.504fF
C359 select_7#0Matrix_1@3_select_7 0 29.504fF
C360 select_8#0Matrix_1@3_select_8 0 29.504fF
C361 select_9#0Matrix_1@3_select_9 0 29.504fF
C362 select_10#0Matrix_1@3_select_10 0 29.504fF
C363 select_11#0Matrix_1@3_select_11 0 29.504fF
C364 select_12#0Matrix_1@3_select_12 0 29.504fF
C365 select_13#0Matrix_1@3_select_13 0 29.504fF
C366 select_14#0Matrix_1@3_select_14 0 29.504fF
C367 select_15#0Matrix_1@3_select_15 0 29.504fF
C368 select_16#0Matrix_1@3_select_16 0 29.504fF
C369 select_17#0Matrix_1@3_select_17 0 29.504fF
C370 select_18#0Matrix_1@3_select_18 0 29.504fF
C371 select_19#0Matrix_1@3_select_19 0 29.504fF
C372 select_20#0Matrix_1@3_select_20 0 29.504fF
C373 select_21#0Matrix_1@3_select_21 0 29.504fF
C374 select_22#0Matrix_1@3_select_22 0 29.504fF
C375 select_23#0Matrix_1@3_select_23 0 29.504fF
C376 select_24#0Matrix_1@3_select_24 0 29.504fF
C377 select_25#0Matrix_1@3_select_25 0 29.504fF
C378 select_26#0Matrix_1@3_select_26 0 29.504fF
C379 select_27#0Matrix_1@3_select_27 0 29.504fF
C380 select_28#0Matrix_1@3_select_28 0 29.504fF
C381 select_29#0Matrix_1@3_select_29 0 29.504fF
C382 select_30#0Matrix_1@3_select_30 0 29.504fF
C383 select_31#0Matrix_1@3_select_31 0 29.504fF
C384 out_0#1pixelv3@0_out 0 45.449fF
** Extracted Parasitic Resistors ***
R0 reset_0 reset_0##0 8.1
C385 reset_0##0 0 29.504fF
R1 reset_0##0 reset_0##1 8.1
C386 reset_0##1 0 29.504fF
R2 reset_0##1 reset_0##2 8.1
C387 reset_0##2 0 29.504fF
R3 reset_0##2 reset_0#0Matrix_1@3_reset_0 8.1
R4 select_0 select_0##0 8.1
C388 select_0##0 0 29.504fF
R5 select_0##0 select_0##1 8.1
C389 select_0##1 0 29.504fF
R6 select_0##1 select_0##2 8.1
C390 select_0##2 0 29.504fF
R7 select_0##2 select_0#0Matrix_1@3_select_0 8.1
R8 reset_1 reset_1##0 8.1
C391 reset_1##0 0 29.504fF
R9 reset_1##0 reset_1##1 8.1
C392 reset_1##1 0 29.504fF
R10 reset_1##1 reset_1##2 8.1
C393 reset_1##2 0 29.504fF
R11 reset_1##2 reset_1#0Matrix_1@3_reset_1 8.1
R12 select_1 select_1##0 8.1
C394 select_1##0 0 29.504fF
R13 select_1##0 select_1##1 8.1
C395 select_1##1 0 29.504fF
R14 select_1##1 select_1##2 8.1
C396 select_1##2 0 29.504fF
R15 select_1##2 select_1#0Matrix_1@3_select_1 8.1
R16 reset_2 reset_2##0 8.1
C397 reset_2##0 0 29.504fF
R17 reset_2##0 reset_2##1 8.1
C398 reset_2##1 0 29.504fF
R18 reset_2##1 reset_2##2 8.1
C399 reset_2##2 0 29.504fF
R19 reset_2##2 reset_2#0Matrix_1@3_reset_2 8.1
R20 select_2 select_2##0 8.1
C400 select_2##0 0 29.504fF
R21 select_2##0 select_2##1 8.1
C401 select_2##1 0 29.504fF
R22 select_2##1 select_2##2 8.1
C402 select_2##2 0 29.504fF
R23 select_2##2 select_2#0Matrix_1@3_select_2 8.1
R24 reset_3 reset_3##0 8.1
C403 reset_3##0 0 29.504fF
R25 reset_3##0 reset_3##1 8.1
C404 reset_3##1 0 29.504fF
R26 reset_3##1 reset_3##2 8.1
C405 reset_3##2 0 29.504fF
R27 reset_3##2 reset_3#0Matrix_1@3_reset_3 8.1
R28 select_3 select_3##0 8.1
C406 select_3##0 0 29.504fF
R29 select_3##0 select_3##1 8.1
C407 select_3##1 0 29.504fF
R30 select_3##1 select_3##2 8.1
C408 select_3##2 0 29.504fF
R31 select_3##2 select_3#0Matrix_1@3_select_3 8.1
R32 reset_4 reset_4##0 8.1
C409 reset_4##0 0 29.504fF
R33 reset_4##0 reset_4##1 8.1
C410 reset_4##1 0 29.504fF
R34 reset_4##1 reset_4##2 8.1
C411 reset_4##2 0 29.504fF
R35 reset_4##2 reset_4#0Matrix_1@3_reset_4 8.1
R36 select_4 select_4##0 8.1
C412 select_4##0 0 29.504fF
R37 select_4##0 select_4##1 8.1
C413 select_4##1 0 29.504fF
R38 select_4##1 select_4##2 8.1
C414 select_4##2 0 29.504fF
R39 select_4##2 select_4#0Matrix_1@3_select_4 8.1
R40 reset_5 reset_5##0 8.1
C415 reset_5##0 0 29.504fF
R41 reset_5##0 reset_5##1 8.1
C416 reset_5##1 0 29.504fF
R42 reset_5##1 reset_5##2 8.1
C417 reset_5##2 0 29.504fF
R43 reset_5##2 reset_5#0Matrix_1@3_reset_5 8.1
R44 select_5 select_5##0 8.1
C418 select_5##0 0 29.504fF
R45 select_5##0 select_5##1 8.1
C419 select_5##1 0 29.504fF
R46 select_5##1 select_5##2 8.1
C420 select_5##2 0 29.504fF
R47 select_5##2 select_5#0Matrix_1@3_select_5 8.1
R48 reset_6 reset_6##0 8.1
C421 reset_6##0 0 29.504fF
R49 reset_6##0 reset_6##1 8.1
C422 reset_6##1 0 29.504fF
R50 reset_6##1 reset_6##2 8.1
C423 reset_6##2 0 29.504fF
R51 reset_6##2 reset_6#0Matrix_1@3_reset_6 8.1
R52 select_6 select_6##0 8.1
C424 select_6##0 0 29.504fF
R53 select_6##0 select_6##1 8.1
C425 select_6##1 0 29.504fF
R54 select_6##1 select_6##2 8.1
C426 select_6##2 0 29.504fF
R55 select_6##2 select_6#0Matrix_1@3_select_6 8.1
R56 reset_7 reset_7##0 8.1
C427 reset_7##0 0 29.504fF
R57 reset_7##0 reset_7##1 8.1
C428 reset_7##1 0 29.504fF
R58 reset_7##1 reset_7##2 8.1
C429 reset_7##2 0 29.504fF
R59 reset_7##2 reset_7#0Matrix_1@3_reset_7 8.1
R60 select_7 select_7##0 8.1
C430 select_7##0 0 29.504fF
R61 select_7##0 select_7##1 8.1
C431 select_7##1 0 29.504fF
R62 select_7##1 select_7##2 8.1
C432 select_7##2 0 29.504fF
R63 select_7##2 select_7#0Matrix_1@3_select_7 8.1
R64 reset_8 reset_8##0 8.1
C433 reset_8##0 0 29.504fF
R65 reset_8##0 reset_8##1 8.1
C434 reset_8##1 0 29.504fF
R66 reset_8##1 reset_8##2 8.1
C435 reset_8##2 0 29.504fF
R67 reset_8##2 reset_8#0Matrix_1@3_reset_8 8.1
R68 select_8 select_8##0 8.1
C436 select_8##0 0 29.504fF
R69 select_8##0 select_8##1 8.1
C437 select_8##1 0 29.504fF
R70 select_8##1 select_8##2 8.1
C438 select_8##2 0 29.504fF
R71 select_8##2 select_8#0Matrix_1@3_select_8 8.1
R72 reset_9 reset_9##0 8.1
C439 reset_9##0 0 29.504fF
R73 reset_9##0 reset_9##1 8.1
C440 reset_9##1 0 29.504fF
R74 reset_9##1 reset_9##2 8.1
C441 reset_9##2 0 29.504fF
R75 reset_9##2 reset_9#0Matrix_1@3_reset_9 8.1
R76 select_9 select_9##0 8.1
C442 select_9##0 0 29.504fF
R77 select_9##0 select_9##1 8.1
C443 select_9##1 0 29.504fF
R78 select_9##1 select_9##2 8.1
C444 select_9##2 0 29.504fF
R79 select_9##2 select_9#0Matrix_1@3_select_9 8.1
R80 reset_10 reset_10##0 8.1
C445 reset_10##0 0 29.504fF
R81 reset_10##0 reset_10##1 8.1
C446 reset_10##1 0 29.504fF
R82 reset_10##1 reset_10##2 8.1
C447 reset_10##2 0 29.504fF
R83 reset_10##2 reset_10#0Matrix_1@3_reset_10 8.1
R84 select_10 select_10##0 8.1
C448 select_10##0 0 29.504fF
R85 select_10##0 select_10##1 8.1
C449 select_10##1 0 29.504fF
R86 select_10##1 select_10##2 8.1
C450 select_10##2 0 29.504fF
R87 select_10##2 select_10#0Matrix_1@3_select_10 8.1
R88 reset_11 reset_11##0 8.1
C451 reset_11##0 0 29.504fF
R89 reset_11##0 reset_11##1 8.1
C452 reset_11##1 0 29.504fF
R90 reset_11##1 reset_11##2 8.1
C453 reset_11##2 0 29.504fF
R91 reset_11##2 reset_11#0Matrix_1@3_reset_11 8.1
R92 select_11 select_11##0 8.1
C454 select_11##0 0 29.504fF
R93 select_11##0 select_11##1 8.1
C455 select_11##1 0 29.504fF
R94 select_11##1 select_11##2 8.1
C456 select_11##2 0 29.504fF
R95 select_11##2 select_11#0Matrix_1@3_select_11 8.1
R96 reset_12 reset_12##0 8.1
C457 reset_12##0 0 29.504fF
R97 reset_12##0 reset_12##1 8.1
C458 reset_12##1 0 29.504fF
R98 reset_12##1 reset_12##2 8.1
C459 reset_12##2 0 29.504fF
R99 reset_12##2 reset_12#0Matrix_1@3_reset_12 8.1
R100 select_12 select_12##0 8.1
C460 select_12##0 0 29.504fF
R101 select_12##0 select_12##1 8.1
C461 select_12##1 0 29.504fF
R102 select_12##1 select_12##2 8.1
C462 select_12##2 0 29.504fF
R103 select_12##2 select_12#0Matrix_1@3_select_12 8.1
R104 reset_13 reset_13##0 8.1
C463 reset_13##0 0 29.504fF
R105 reset_13##0 reset_13##1 8.1
C464 reset_13##1 0 29.504fF
R106 reset_13##1 reset_13##2 8.1
C465 reset_13##2 0 29.504fF
R107 reset_13##2 reset_13#0Matrix_1@3_reset_13 8.1
R108 select_13 select_13##0 8.1
C466 select_13##0 0 29.504fF
R109 select_13##0 select_13##1 8.1
C467 select_13##1 0 29.504fF
R110 select_13##1 select_13##2 8.1
C468 select_13##2 0 29.504fF
R111 select_13##2 select_13#0Matrix_1@3_select_13 8.1
R112 reset_14 reset_14##0 8.1
C469 reset_14##0 0 29.504fF
R113 reset_14##0 reset_14##1 8.1
C470 reset_14##1 0 29.504fF
R114 reset_14##1 reset_14##2 8.1
C471 reset_14##2 0 29.504fF
R115 reset_14##2 reset_14#0Matrix_1@3_reset_14 8.1
R116 select_14 select_14##0 8.1
C472 select_14##0 0 29.504fF
R117 select_14##0 select_14##1 8.1
C473 select_14##1 0 29.504fF
R118 select_14##1 select_14##2 8.1
C474 select_14##2 0 29.504fF
R119 select_14##2 select_14#0Matrix_1@3_select_14 8.1
R120 reset_15 reset_15##0 8.1
C475 reset_15##0 0 29.504fF
R121 reset_15##0 reset_15##1 8.1
C476 reset_15##1 0 29.504fF
R122 reset_15##1 reset_15##2 8.1
C477 reset_15##2 0 29.504fF
R123 reset_15##2 reset_15#0Matrix_1@3_reset_15 8.1
R124 select_15 select_15##0 8.1
C478 select_15##0 0 29.504fF
R125 select_15##0 select_15##1 8.1
C479 select_15##1 0 29.504fF
R126 select_15##1 select_15##2 8.1
C480 select_15##2 0 29.504fF
R127 select_15##2 select_15#0Matrix_1@3_select_15 8.1
R128 reset_16 reset_16##0 8.1
C481 reset_16##0 0 29.504fF
R129 reset_16##0 reset_16##1 8.1
C482 reset_16##1 0 29.504fF
R130 reset_16##1 reset_16##2 8.1
C483 reset_16##2 0 29.504fF
R131 reset_16##2 reset_16#0Matrix_1@3_reset_16 8.1
R132 select_16 select_16##0 8.1
C484 select_16##0 0 29.504fF
R133 select_16##0 select_16##1 8.1
C485 select_16##1 0 29.504fF
R134 select_16##1 select_16##2 8.1
C486 select_16##2 0 29.504fF
R135 select_16##2 select_16#0Matrix_1@3_select_16 8.1
R136 reset_17 reset_17##0 8.1
C487 reset_17##0 0 29.504fF
R137 reset_17##0 reset_17##1 8.1
C488 reset_17##1 0 29.504fF
R138 reset_17##1 reset_17##2 8.1
C489 reset_17##2 0 29.504fF
R139 reset_17##2 reset_17#0Matrix_1@3_reset_17 8.1
R140 select_17 select_17##0 8.1
C490 select_17##0 0 29.504fF
R141 select_17##0 select_17##1 8.1
C491 select_17##1 0 29.504fF
R142 select_17##1 select_17##2 8.1
C492 select_17##2 0 29.504fF
R143 select_17##2 select_17#0Matrix_1@3_select_17 8.1
R144 reset_18 reset_18##0 8.1
C493 reset_18##0 0 29.504fF
R145 reset_18##0 reset_18##1 8.1
C494 reset_18##1 0 29.504fF
R146 reset_18##1 reset_18##2 8.1
C495 reset_18##2 0 29.504fF
R147 reset_18##2 reset_18#0Matrix_1@3_reset_18 8.1
R148 select_18 select_18##0 8.1
C496 select_18##0 0 29.504fF
R149 select_18##0 select_18##1 8.1
C497 select_18##1 0 29.504fF
R150 select_18##1 select_18##2 8.1
C498 select_18##2 0 29.504fF
R151 select_18##2 select_18#0Matrix_1@3_select_18 8.1
R152 reset_19 reset_19##0 8.1
C499 reset_19##0 0 29.504fF
R153 reset_19##0 reset_19##1 8.1
C500 reset_19##1 0 29.504fF
R154 reset_19##1 reset_19##2 8.1
C501 reset_19##2 0 29.504fF
R155 reset_19##2 reset_19#0Matrix_1@3_reset_19 8.1
R156 select_19 select_19##0 8.1
C502 select_19##0 0 29.504fF
R157 select_19##0 select_19##1 8.1
C503 select_19##1 0 29.504fF
R158 select_19##1 select_19##2 8.1
C504 select_19##2 0 29.504fF
R159 select_19##2 select_19#0Matrix_1@3_select_19 8.1
R160 reset_20 reset_20##0 8.1
C505 reset_20##0 0 29.504fF
R161 reset_20##0 reset_20##1 8.1
C506 reset_20##1 0 29.504fF
R162 reset_20##1 reset_20##2 8.1
C507 reset_20##2 0 29.504fF
R163 reset_20##2 reset_20#0Matrix_1@3_reset_20 8.1
R164 select_20 select_20##0 8.1
C508 select_20##0 0 29.504fF
R165 select_20##0 select_20##1 8.1
C509 select_20##1 0 29.504fF
R166 select_20##1 select_20##2 8.1
C510 select_20##2 0 29.504fF
R167 select_20##2 select_20#0Matrix_1@3_select_20 8.1
R168 reset_21 reset_21##0 8.1
C511 reset_21##0 0 29.504fF
R169 reset_21##0 reset_21##1 8.1
C512 reset_21##1 0 29.504fF
R170 reset_21##1 reset_21##2 8.1
C513 reset_21##2 0 29.504fF
R171 reset_21##2 reset_21#0Matrix_1@3_reset_21 8.1
R172 select_21 select_21##0 8.1
C514 select_21##0 0 29.504fF
R173 select_21##0 select_21##1 8.1
C515 select_21##1 0 29.504fF
R174 select_21##1 select_21##2 8.1
C516 select_21##2 0 29.504fF
R175 select_21##2 select_21#0Matrix_1@3_select_21 8.1
R176 reset_22 reset_22##0 8.1
C517 reset_22##0 0 29.504fF
R177 reset_22##0 reset_22##1 8.1
C518 reset_22##1 0 29.504fF
R178 reset_22##1 reset_22##2 8.1
C519 reset_22##2 0 29.504fF
R179 reset_22##2 reset_22#0Matrix_1@3_reset_22 8.1
R180 select_22 select_22##0 8.1
C520 select_22##0 0 29.504fF
R181 select_22##0 select_22##1 8.1
C521 select_22##1 0 29.504fF
R182 select_22##1 select_22##2 8.1
C522 select_22##2 0 29.504fF
R183 select_22##2 select_22#0Matrix_1@3_select_22 8.1
R184 reset_23 reset_23##0 8.1
C523 reset_23##0 0 29.504fF
R185 reset_23##0 reset_23##1 8.1
C524 reset_23##1 0 29.504fF
R186 reset_23##1 reset_23##2 8.1
C525 reset_23##2 0 29.504fF
R187 reset_23##2 reset_23#0Matrix_1@3_reset_23 8.1
R188 select_23 select_23##0 8.1
C526 select_23##0 0 29.504fF
R189 select_23##0 select_23##1 8.1
C527 select_23##1 0 29.504fF
R190 select_23##1 select_23##2 8.1
C528 select_23##2 0 29.504fF
R191 select_23##2 select_23#0Matrix_1@3_select_23 8.1
R192 reset_24 reset_24##0 8.1
C529 reset_24##0 0 29.504fF
R193 reset_24##0 reset_24##1 8.1
C530 reset_24##1 0 29.504fF
R194 reset_24##1 reset_24##2 8.1
C531 reset_24##2 0 29.504fF
R195 reset_24##2 reset_24#0Matrix_1@3_reset_24 8.1
R196 select_24 select_24##0 8.1
C532 select_24##0 0 29.504fF
R197 select_24##0 select_24##1 8.1
C533 select_24##1 0 29.504fF
R198 select_24##1 select_24##2 8.1
C534 select_24##2 0 29.504fF
R199 select_24##2 select_24#0Matrix_1@3_select_24 8.1
R200 reset_25 reset_25##0 8.1
C535 reset_25##0 0 29.504fF
R201 reset_25##0 reset_25##1 8.1
C536 reset_25##1 0 29.504fF
R202 reset_25##1 reset_25##2 8.1
C537 reset_25##2 0 29.504fF
R203 reset_25##2 reset_25#0Matrix_1@3_reset_25 8.1
R204 select_25 select_25##0 8.1
C538 select_25##0 0 29.504fF
R205 select_25##0 select_25##1 8.1
C539 select_25##1 0 29.504fF
R206 select_25##1 select_25##2 8.1
C540 select_25##2 0 29.504fF
R207 select_25##2 select_25#0Matrix_1@3_select_25 8.1
R208 reset_26 reset_26##0 8.1
C541 reset_26##0 0 29.504fF
R209 reset_26##0 reset_26##1 8.1
C542 reset_26##1 0 29.504fF
R210 reset_26##1 reset_26##2 8.1
C543 reset_26##2 0 29.504fF
R211 reset_26##2 reset_26#0Matrix_1@3_reset_26 8.1
R212 select_26 select_26##0 8.1
C544 select_26##0 0 29.504fF
R213 select_26##0 select_26##1 8.1
C545 select_26##1 0 29.504fF
R214 select_26##1 select_26##2 8.1
C546 select_26##2 0 29.504fF
R215 select_26##2 select_26#0Matrix_1@3_select_26 8.1
R216 reset_27 reset_27##0 8.1
C547 reset_27##0 0 29.504fF
R217 reset_27##0 reset_27##1 8.1
C548 reset_27##1 0 29.504fF
R218 reset_27##1 reset_27##2 8.1
C549 reset_27##2 0 29.504fF
R219 reset_27##2 reset_27#0Matrix_1@3_reset_27 8.1
R220 select_27 select_27##0 8.1
C550 select_27##0 0 29.504fF
R221 select_27##0 select_27##1 8.1
C551 select_27##1 0 29.504fF
R222 select_27##1 select_27##2 8.1
C552 select_27##2 0 29.504fF
R223 select_27##2 select_27#0Matrix_1@3_select_27 8.1
R224 reset_28 reset_28##0 8.1
C553 reset_28##0 0 29.504fF
R225 reset_28##0 reset_28##1 8.1
C554 reset_28##1 0 29.504fF
R226 reset_28##1 reset_28##2 8.1
C555 reset_28##2 0 29.504fF
R227 reset_28##2 reset_28#0Matrix_1@3_reset_28 8.1
R228 select_28 select_28##0 8.1
C556 select_28##0 0 29.504fF
R229 select_28##0 select_28##1 8.1
C557 select_28##1 0 29.504fF
R230 select_28##1 select_28##2 8.1
C558 select_28##2 0 29.504fF
R231 select_28##2 select_28#0Matrix_1@3_select_28 8.1
R232 reset_29 reset_29##0 8.1
C559 reset_29##0 0 29.504fF
R233 reset_29##0 reset_29##1 8.1
C560 reset_29##1 0 29.504fF
R234 reset_29##1 reset_29##2 8.1
C561 reset_29##2 0 29.504fF
R235 reset_29##2 reset_29#0Matrix_1@3_reset_29 8.1
R236 select_29 select_29##0 8.1
C562 select_29##0 0 29.504fF
R237 select_29##0 select_29##1 8.1
C563 select_29##1 0 29.504fF
R238 select_29##1 select_29##2 8.1
C564 select_29##2 0 29.504fF
R239 select_29##2 select_29#0Matrix_1@3_select_29 8.1
R240 reset_30 reset_30##0 8.1
C565 reset_30##0 0 29.504fF
R241 reset_30##0 reset_30##1 8.1
C566 reset_30##1 0 29.504fF
R242 reset_30##1 reset_30##2 8.1
C567 reset_30##2 0 29.504fF
R243 reset_30##2 reset_30#0Matrix_1@3_reset_30 8.1
R244 select_30 select_30##0 8.1
C568 select_30##0 0 29.504fF
R245 select_30##0 select_30##1 8.1
C569 select_30##1 0 29.504fF
R246 select_30##1 select_30##2 8.1
C570 select_30##2 0 29.504fF
R247 select_30##2 select_30#0Matrix_1@3_select_30 8.1
R248 select_31 select_31##0 8.1
C571 select_31##0 0 29.504fF
R249 select_31##0 select_31##1 8.1
C572 select_31##1 0 29.504fF
R250 select_31##1 select_31##2 8.1
C573 select_31##2 0 29.504fF
R251 select_31##2 select_31#0Matrix_1@3_select_31 8.1
R252 reset_31 reset_31##0 8.1
C574 reset_31##0 0 29.504fF
R253 reset_31##0 reset_31##1 8.1
C575 reset_31##1 0 29.504fF
R254 reset_31##1 reset_31##2 8.1
C576 reset_31##2 0 29.504fF
R255 reset_31##2 reset_31#0Matrix_1@3_reset_31 8.1
R256 reset_32 reset_32##0 8.1
C577 reset_32##0 0 29.504fF
R257 reset_32##0 reset_32##1 8.1
C578 reset_32##1 0 29.504fF
R258 reset_32##1 reset_32##2 8.1
C579 reset_32##2 0 29.504fF
R259 reset_32##2 reset_32#0Matrix_1@1_reset_0 8.1
R260 select_32 select_32##0 8.1
C580 select_32##0 0 29.504fF
R261 select_32##0 select_32##1 8.1
C581 select_32##1 0 29.504fF
R262 select_32##1 select_32##2 8.1
C582 select_32##2 0 29.504fF
R263 select_32##2 select_32#0Matrix_1@1_select_0 8.1
R264 reset_33 reset_33##0 8.1
C583 reset_33##0 0 29.504fF
R265 reset_33##0 reset_33##1 8.1
C584 reset_33##1 0 29.504fF
R266 reset_33##1 reset_33##2 8.1
C585 reset_33##2 0 29.504fF
R267 reset_33##2 reset_33#0Matrix_1@1_reset_1 8.1
R268 select_33 select_33##0 8.1
C586 select_33##0 0 29.504fF
R269 select_33##0 select_33##1 8.1
C587 select_33##1 0 29.504fF
R270 select_33##1 select_33##2 8.1
C588 select_33##2 0 29.504fF
R271 select_33##2 select_33#0Matrix_1@1_select_1 8.1
R272 reset_34 reset_34##0 8.1
C589 reset_34##0 0 29.504fF
R273 reset_34##0 reset_34##1 8.1
C590 reset_34##1 0 29.504fF
R274 reset_34##1 reset_34##2 8.1
C591 reset_34##2 0 29.504fF
R275 reset_34##2 reset_34#0Matrix_1@1_reset_2 8.1
R276 select_34 select_34##0 8.1
C592 select_34##0 0 29.504fF
R277 select_34##0 select_34##1 8.1
C593 select_34##1 0 29.504fF
R278 select_34##1 select_34##2 8.1
C594 select_34##2 0 29.504fF
R279 select_34##2 select_34#0Matrix_1@1_select_2 8.1
R280 reset_35 reset_35##0 8.1
C595 reset_35##0 0 29.504fF
R281 reset_35##0 reset_35##1 8.1
C596 reset_35##1 0 29.504fF
R282 reset_35##1 reset_35##2 8.1
C597 reset_35##2 0 29.504fF
R283 reset_35##2 reset_35#0Matrix_1@1_reset_3 8.1
R284 select_35 select_35##0 8.1
C598 select_35##0 0 29.504fF
R285 select_35##0 select_35##1 8.1
C599 select_35##1 0 29.504fF
R286 select_35##1 select_35##2 8.1
C600 select_35##2 0 29.504fF
R287 select_35##2 select_35#0Matrix_1@1_select_3 8.1
R288 reset_36 reset_36##0 8.1
C601 reset_36##0 0 29.504fF
R289 reset_36##0 reset_36##1 8.1
C602 reset_36##1 0 29.504fF
R290 reset_36##1 reset_36##2 8.1
C603 reset_36##2 0 29.504fF
R291 reset_36##2 reset_36#0Matrix_1@1_reset_4 8.1
R292 select_36 select_36##0 8.1
C604 select_36##0 0 29.504fF
R293 select_36##0 select_36##1 8.1
C605 select_36##1 0 29.504fF
R294 select_36##1 select_36##2 8.1
C606 select_36##2 0 29.504fF
R295 select_36##2 select_36#0Matrix_1@1_select_4 8.1
R296 reset_37 reset_37##0 8.1
C607 reset_37##0 0 29.504fF
R297 reset_37##0 reset_37##1 8.1
C608 reset_37##1 0 29.504fF
R298 reset_37##1 reset_37##2 8.1
C609 reset_37##2 0 29.504fF
R299 reset_37##2 reset_37#0Matrix_1@1_reset_5 8.1
R300 select_37 select_37##0 8.1
C610 select_37##0 0 29.504fF
R301 select_37##0 select_37##1 8.1
C611 select_37##1 0 29.504fF
R302 select_37##1 select_37##2 8.1
C612 select_37##2 0 29.504fF
R303 select_37##2 select_37#0Matrix_1@1_select_5 8.1
R304 reset_38 reset_38##0 8.1
C613 reset_38##0 0 29.504fF
R305 reset_38##0 reset_38##1 8.1
C614 reset_38##1 0 29.504fF
R306 reset_38##1 reset_38##2 8.1
C615 reset_38##2 0 29.504fF
R307 reset_38##2 reset_38#0Matrix_1@1_reset_6 8.1
R308 select_38 select_38##0 8.1
C616 select_38##0 0 29.504fF
R309 select_38##0 select_38##1 8.1
C617 select_38##1 0 29.504fF
R310 select_38##1 select_38##2 8.1
C618 select_38##2 0 29.504fF
R311 select_38##2 select_38#0Matrix_1@1_select_6 8.1
R312 reset_39 reset_39##0 8.1
C619 reset_39##0 0 29.504fF
R313 reset_39##0 reset_39##1 8.1
C620 reset_39##1 0 29.504fF
R314 reset_39##1 reset_39##2 8.1
C621 reset_39##2 0 29.504fF
R315 reset_39##2 reset_39#0Matrix_1@1_reset_7 8.1
R316 select_39 select_39##0 8.1
C622 select_39##0 0 29.504fF
R317 select_39##0 select_39##1 8.1
C623 select_39##1 0 29.504fF
R318 select_39##1 select_39##2 8.1
C624 select_39##2 0 29.504fF
R319 select_39##2 select_39#0Matrix_1@1_select_7 8.1
R320 reset_40 reset_40##0 8.1
C625 reset_40##0 0 29.504fF
R321 reset_40##0 reset_40##1 8.1
C626 reset_40##1 0 29.504fF
R322 reset_40##1 reset_40##2 8.1
C627 reset_40##2 0 29.504fF
R323 reset_40##2 reset_40#0Matrix_1@1_reset_8 8.1
R324 select_40 select_40##0 8.1
C628 select_40##0 0 29.504fF
R325 select_40##0 select_40##1 8.1
C629 select_40##1 0 29.504fF
R326 select_40##1 select_40##2 8.1
C630 select_40##2 0 29.504fF
R327 select_40##2 select_40#0Matrix_1@1_select_8 8.1
R328 reset_41 reset_41##0 8.1
C631 reset_41##0 0 29.504fF
R329 reset_41##0 reset_41##1 8.1
C632 reset_41##1 0 29.504fF
R330 reset_41##1 reset_41##2 8.1
C633 reset_41##2 0 29.504fF
R331 reset_41##2 reset_41#0Matrix_1@1_reset_9 8.1
R332 select_41 select_41##0 8.1
C634 select_41##0 0 29.504fF
R333 select_41##0 select_41##1 8.1
C635 select_41##1 0 29.504fF
R334 select_41##1 select_41##2 8.1
C636 select_41##2 0 29.504fF
R335 select_41##2 select_41#0Matrix_1@1_select_9 8.1
R336 reset_42 reset_42##0 8.1
C637 reset_42##0 0 29.504fF
R337 reset_42##0 reset_42##1 8.1
C638 reset_42##1 0 29.504fF
R338 reset_42##1 reset_42##2 8.1
C639 reset_42##2 0 29.504fF
R339 reset_42##2 reset_42#0Matrix_1@1_reset_10 8.1
R340 select_42 select_42##0 8.1
C640 select_42##0 0 29.504fF
R341 select_42##0 select_42##1 8.1
C641 select_42##1 0 29.504fF
R342 select_42##1 select_42##2 8.1
C642 select_42##2 0 29.504fF
R343 select_42##2 select_42#0Matrix_1@1_select_10 8.1
R344 reset_43 reset_43##0 8.1
C643 reset_43##0 0 29.504fF
R345 reset_43##0 reset_43##1 8.1
C644 reset_43##1 0 29.504fF
R346 reset_43##1 reset_43##2 8.1
C645 reset_43##2 0 29.504fF
R347 reset_43##2 reset_43#0Matrix_1@1_reset_11 8.1
R348 select_43 select_43##0 8.1
C646 select_43##0 0 29.504fF
R349 select_43##0 select_43##1 8.1
C647 select_43##1 0 29.504fF
R350 select_43##1 select_43##2 8.1
C648 select_43##2 0 29.504fF
R351 select_43##2 select_43#0Matrix_1@1_select_11 8.1
R352 reset_44 reset_44##0 8.1
C649 reset_44##0 0 29.504fF
R353 reset_44##0 reset_44##1 8.1
C650 reset_44##1 0 29.504fF
R354 reset_44##1 reset_44##2 8.1
C651 reset_44##2 0 29.504fF
R355 reset_44##2 reset_44#0Matrix_1@1_reset_12 8.1
R356 select_44 select_44##0 8.1
C652 select_44##0 0 29.504fF
R357 select_44##0 select_44##1 8.1
C653 select_44##1 0 29.504fF
R358 select_44##1 select_44##2 8.1
C654 select_44##2 0 29.504fF
R359 select_44##2 select_44#0Matrix_1@1_select_12 8.1
R360 reset_45 reset_45##0 8.1
C655 reset_45##0 0 29.504fF
R361 reset_45##0 reset_45##1 8.1
C656 reset_45##1 0 29.504fF
R362 reset_45##1 reset_45##2 8.1
C657 reset_45##2 0 29.504fF
R363 reset_45##2 reset_45#0Matrix_1@1_reset_13 8.1
R364 select_45 select_45##0 8.1
C658 select_45##0 0 29.504fF
R365 select_45##0 select_45##1 8.1
C659 select_45##1 0 29.504fF
R366 select_45##1 select_45##2 8.1
C660 select_45##2 0 29.504fF
R367 select_45##2 select_45#0Matrix_1@1_select_13 8.1
R368 reset_46 reset_46##0 8.1
C661 reset_46##0 0 29.504fF
R369 reset_46##0 reset_46##1 8.1
C662 reset_46##1 0 29.504fF
R370 reset_46##1 reset_46##2 8.1
C663 reset_46##2 0 29.504fF
R371 reset_46##2 reset_46#0Matrix_1@1_reset_14 8.1
R372 select_46 select_46##0 8.1
C664 select_46##0 0 29.504fF
R373 select_46##0 select_46##1 8.1
C665 select_46##1 0 29.504fF
R374 select_46##1 select_46##2 8.1
C666 select_46##2 0 29.504fF
R375 select_46##2 select_46#0Matrix_1@1_select_14 8.1
R376 reset_47 reset_47##0 8.1
C667 reset_47##0 0 29.504fF
R377 reset_47##0 reset_47##1 8.1
C668 reset_47##1 0 29.504fF
R378 reset_47##1 reset_47##2 8.1
C669 reset_47##2 0 29.504fF
R379 reset_47##2 reset_47#0Matrix_1@1_reset_15 8.1
R380 select_47 select_47##0 8.1
C670 select_47##0 0 29.504fF
R381 select_47##0 select_47##1 8.1
C671 select_47##1 0 29.504fF
R382 select_47##1 select_47##2 8.1
C672 select_47##2 0 29.504fF
R383 select_47##2 select_47#0Matrix_1@1_select_15 8.1
R384 reset_48 reset_48##0 8.1
C673 reset_48##0 0 29.504fF
R385 reset_48##0 reset_48##1 8.1
C674 reset_48##1 0 29.504fF
R386 reset_48##1 reset_48##2 8.1
C675 reset_48##2 0 29.504fF
R387 reset_48##2 reset_48#0Matrix_1@1_reset_16 8.1
R388 select_48 select_48##0 8.1
C676 select_48##0 0 29.504fF
R389 select_48##0 select_48##1 8.1
C677 select_48##1 0 29.504fF
R390 select_48##1 select_48##2 8.1
C678 select_48##2 0 29.504fF
R391 select_48##2 select_48#0Matrix_1@1_select_16 8.1
R392 reset_49 reset_49##0 8.1
C679 reset_49##0 0 29.504fF
R393 reset_49##0 reset_49##1 8.1
C680 reset_49##1 0 29.504fF
R394 reset_49##1 reset_49##2 8.1
C681 reset_49##2 0 29.504fF
R395 reset_49##2 reset_49#0Matrix_1@1_reset_17 8.1
R396 select_49 select_49##0 8.1
C682 select_49##0 0 29.504fF
R397 select_49##0 select_49##1 8.1
C683 select_49##1 0 29.504fF
R398 select_49##1 select_49##2 8.1
C684 select_49##2 0 29.504fF
R399 select_49##2 select_49#0Matrix_1@1_select_17 8.1
R400 reset_50 reset_50##0 8.1
C685 reset_50##0 0 29.504fF
R401 reset_50##0 reset_50##1 8.1
C686 reset_50##1 0 29.504fF
R402 reset_50##1 reset_50##2 8.1
C687 reset_50##2 0 29.504fF
R403 reset_50##2 reset_50#0Matrix_1@1_reset_18 8.1
R404 select_50 select_50##0 8.1
C688 select_50##0 0 29.504fF
R405 select_50##0 select_50##1 8.1
C689 select_50##1 0 29.504fF
R406 select_50##1 select_50##2 8.1
C690 select_50##2 0 29.504fF
R407 select_50##2 select_50#0Matrix_1@1_select_18 8.1
R408 reset_51 reset_51##0 8.1
C691 reset_51##0 0 29.504fF
R409 reset_51##0 reset_51##1 8.1
C692 reset_51##1 0 29.504fF
R410 reset_51##1 reset_51##2 8.1
C693 reset_51##2 0 29.504fF
R411 reset_51##2 reset_51#0Matrix_1@1_reset_19 8.1
R412 select_51 select_51##0 8.1
C694 select_51##0 0 29.504fF
R413 select_51##0 select_51##1 8.1
C695 select_51##1 0 29.504fF
R414 select_51##1 select_51##2 8.1
C696 select_51##2 0 29.504fF
R415 select_51##2 select_51#0Matrix_1@1_select_19 8.1
R416 reset_52 reset_52##0 8.1
C697 reset_52##0 0 29.504fF
R417 reset_52##0 reset_52##1 8.1
C698 reset_52##1 0 29.504fF
R418 reset_52##1 reset_52##2 8.1
C699 reset_52##2 0 29.504fF
R419 reset_52##2 reset_52#0Matrix_1@1_reset_20 8.1
R420 select_52 select_52##0 8.1
C700 select_52##0 0 29.504fF
R421 select_52##0 select_52##1 8.1
C701 select_52##1 0 29.504fF
R422 select_52##1 select_52##2 8.1
C702 select_52##2 0 29.504fF
R423 select_52##2 select_52#0Matrix_1@1_select_20 8.1
R424 reset_53 reset_53##0 8.1
C703 reset_53##0 0 29.504fF
R425 reset_53##0 reset_53##1 8.1
C704 reset_53##1 0 29.504fF
R426 reset_53##1 reset_53##2 8.1
C705 reset_53##2 0 29.504fF
R427 reset_53##2 reset_53#0Matrix_1@1_reset_21 8.1
R428 select_53 select_53##0 8.1
C706 select_53##0 0 29.504fF
R429 select_53##0 select_53##1 8.1
C707 select_53##1 0 29.504fF
R430 select_53##1 select_53##2 8.1
C708 select_53##2 0 29.504fF
R431 select_53##2 select_53#0Matrix_1@1_select_21 8.1
R432 reset_54 reset_54##0 8.1
C709 reset_54##0 0 29.504fF
R433 reset_54##0 reset_54##1 8.1
C710 reset_54##1 0 29.504fF
R434 reset_54##1 reset_54##2 8.1
C711 reset_54##2 0 29.504fF
R435 reset_54##2 reset_54#0Matrix_1@1_reset_22 8.1
R436 select_54 select_54##0 8.1
C712 select_54##0 0 29.504fF
R437 select_54##0 select_54##1 8.1
C713 select_54##1 0 29.504fF
R438 select_54##1 select_54##2 8.1
C714 select_54##2 0 29.504fF
R439 select_54##2 select_54#0Matrix_1@1_select_22 8.1
R440 reset_55 reset_55##0 8.1
C715 reset_55##0 0 29.504fF
R441 reset_55##0 reset_55##1 8.1
C716 reset_55##1 0 29.504fF
R442 reset_55##1 reset_55##2 8.1
C717 reset_55##2 0 29.504fF
R443 reset_55##2 reset_55#0Matrix_1@1_reset_23 8.1
R444 select_55 select_55##0 8.1
C718 select_55##0 0 29.504fF
R445 select_55##0 select_55##1 8.1
C719 select_55##1 0 29.504fF
R446 select_55##1 select_55##2 8.1
C720 select_55##2 0 29.504fF
R447 select_55##2 select_55#0Matrix_1@1_select_23 8.1
R448 reset_56 reset_56##0 8.1
C721 reset_56##0 0 29.504fF
R449 reset_56##0 reset_56##1 8.1
C722 reset_56##1 0 29.504fF
R450 reset_56##1 reset_56##2 8.1
C723 reset_56##2 0 29.504fF
R451 reset_56##2 reset_56#0Matrix_1@1_reset_24 8.1
R452 select_56 select_56##0 8.1
C724 select_56##0 0 29.504fF
R453 select_56##0 select_56##1 8.1
C725 select_56##1 0 29.504fF
R454 select_56##1 select_56##2 8.1
C726 select_56##2 0 29.504fF
R455 select_56##2 select_56#0Matrix_1@1_select_24 8.1
R456 reset_57 reset_57##0 8.1
C727 reset_57##0 0 29.504fF
R457 reset_57##0 reset_57##1 8.1
C728 reset_57##1 0 29.504fF
R458 reset_57##1 reset_57##2 8.1
C729 reset_57##2 0 29.504fF
R459 reset_57##2 reset_57#0Matrix_1@1_reset_25 8.1
R460 select_57 select_57##0 8.1
C730 select_57##0 0 29.504fF
R461 select_57##0 select_57##1 8.1
C731 select_57##1 0 29.504fF
R462 select_57##1 select_57##2 8.1
C732 select_57##2 0 29.504fF
R463 select_57##2 select_57#0Matrix_1@1_select_25 8.1
R464 reset_58 reset_58##0 8.1
C733 reset_58##0 0 29.504fF
R465 reset_58##0 reset_58##1 8.1
C734 reset_58##1 0 29.504fF
R466 reset_58##1 reset_58##2 8.1
C735 reset_58##2 0 29.504fF
R467 reset_58##2 reset_58#0Matrix_1@1_reset_26 8.1
R468 select_58 select_58##0 8.1
C736 select_58##0 0 29.504fF
R469 select_58##0 select_58##1 8.1
C737 select_58##1 0 29.504fF
R470 select_58##1 select_58##2 8.1
C738 select_58##2 0 29.504fF
R471 select_58##2 select_58#0Matrix_1@1_select_26 8.1
R472 reset_59 reset_59##0 8.1
C739 reset_59##0 0 29.504fF
R473 reset_59##0 reset_59##1 8.1
C740 reset_59##1 0 29.504fF
R474 reset_59##1 reset_59##2 8.1
C741 reset_59##2 0 29.504fF
R475 reset_59##2 reset_59#0Matrix_1@1_reset_27 8.1
R476 select_59 select_59##0 8.1
C742 select_59##0 0 29.504fF
R477 select_59##0 select_59##1 8.1
C743 select_59##1 0 29.504fF
R478 select_59##1 select_59##2 8.1
C744 select_59##2 0 29.504fF
R479 select_59##2 select_59#0Matrix_1@1_select_27 8.1
R480 reset_60 reset_60##0 8.1
C745 reset_60##0 0 29.504fF
R481 reset_60##0 reset_60##1 8.1
C746 reset_60##1 0 29.504fF
R482 reset_60##1 reset_60##2 8.1
C747 reset_60##2 0 29.504fF
R483 reset_60##2 reset_60#0Matrix_1@1_reset_28 8.1
R484 select_60 select_60##0 8.1
C748 select_60##0 0 29.504fF
R485 select_60##0 select_60##1 8.1
C749 select_60##1 0 29.504fF
R486 select_60##1 select_60##2 8.1
C750 select_60##2 0 29.504fF
R487 select_60##2 select_60#0Matrix_1@1_select_28 8.1
R488 reset_61 reset_61##0 8.1
C751 reset_61##0 0 29.504fF
R489 reset_61##0 reset_61##1 8.1
C752 reset_61##1 0 29.504fF
R490 reset_61##1 reset_61##2 8.1
C753 reset_61##2 0 29.504fF
R491 reset_61##2 reset_61#0Matrix_1@1_reset_29 8.1
R492 select_61 select_61##0 8.1
C754 select_61##0 0 29.504fF
R493 select_61##0 select_61##1 8.1
C755 select_61##1 0 29.504fF
R494 select_61##1 select_61##2 8.1
C756 select_61##2 0 29.504fF
R495 select_61##2 select_61#0Matrix_1@1_select_29 8.1
R496 reset_62 reset_62##0 8.1
C757 reset_62##0 0 29.504fF
R497 reset_62##0 reset_62##1 8.1
C758 reset_62##1 0 29.504fF
R498 reset_62##1 reset_62##2 8.1
C759 reset_62##2 0 29.504fF
R499 reset_62##2 reset_62#0Matrix_1@1_reset_30 8.1
R500 select_62 select_62##0 8.1
C760 select_62##0 0 29.504fF
R501 select_62##0 select_62##1 8.1
C761 select_62##1 0 29.504fF
R502 select_62##1 select_62##2 8.1
C762 select_62##2 0 29.504fF
R503 select_62##2 select_62#0Matrix_1@1_select_30 8.1
R504 select_63 select_63##0 8.1
C763 select_63##0 0 29.504fF
R505 select_63##0 select_63##1 8.1
C764 select_63##1 0 29.504fF
R506 select_63##1 select_63##2 8.1
C765 select_63##2 0 29.504fF
R507 select_63##2 select_63#0Matrix_1@1_select_31 8.1
R508 reset_63 reset_63##0 8.1
C766 reset_63##0 0 29.504fF
R509 reset_63##0 reset_63##1 8.1
C767 reset_63##1 0 29.504fF
R510 reset_63##1 reset_63##2 8.1
C768 reset_63##2 0 29.504fF
R511 reset_63##2 reset_63#0Matrix_1@1_reset_31 8.1
R512 out_0#0Matrix_1@2_out_0 out_0#0Matrix_1@2_out_0##0 8.083
C769 out_0#0Matrix_1@2_out_0##0 0 36.398fF
R513 out_0#0Matrix_1@2_out_0##0 out_0#0Matrix_1@2_out_0##1 8.083
C770 out_0#0Matrix_1@2_out_0##1 0 36.398fF
R514 out_0#0Matrix_1@2_out_0##1 out_0#0Matrix_1@2_out_0##2 8.083
C771 out_0#0Matrix_1@2_out_0##2 0 36.398fF
R515 out_0#0Matrix_1@2_out_0##2 out_0 8.083
R516 out_1#0Matrix_1@2_out_1 out_1#0Matrix_1@2_out_1##0 8.083
C772 out_1#0Matrix_1@2_out_1##0 0 36.398fF
R517 out_1#0Matrix_1@2_out_1##0 out_1#0Matrix_1@2_out_1##1 8.083
C773 out_1#0Matrix_1@2_out_1##1 0 36.398fF
R518 out_1#0Matrix_1@2_out_1##1 out_1#0Matrix_1@2_out_1##2 8.083
C774 out_1#0Matrix_1@2_out_1##2 0 36.398fF
R519 out_1#0Matrix_1@2_out_1##2 out_1 8.083
R520 out_2#0Matrix_1@2_out_2 out_2#0Matrix_1@2_out_2##0 8.083
C775 out_2#0Matrix_1@2_out_2##0 0 36.398fF
R521 out_2#0Matrix_1@2_out_2##0 out_2#0Matrix_1@2_out_2##1 8.083
C776 out_2#0Matrix_1@2_out_2##1 0 36.398fF
R522 out_2#0Matrix_1@2_out_2##1 out_2#0Matrix_1@2_out_2##2 8.083
C777 out_2#0Matrix_1@2_out_2##2 0 36.398fF
R523 out_2#0Matrix_1@2_out_2##2 out_2 8.083
R524 out_3 out_3##0 8.083
C778 out_3##0 0 36.398fF
R525 out_3##0 out_3##1 8.083
C779 out_3##1 0 36.398fF
R526 out_3##1 out_3##2 8.083
C780 out_3##2 0 36.398fF
R527 out_3##2 out_3#0Matrix_1@2_out_3 8.083
R528 out_4#0Matrix_1@2_out_4 out_4#0Matrix_1@2_out_4##0 8.083
C781 out_4#0Matrix_1@2_out_4##0 0 36.398fF
R529 out_4#0Matrix_1@2_out_4##0 out_4#0Matrix_1@2_out_4##1 8.083
C782 out_4#0Matrix_1@2_out_4##1 0 36.398fF
R530 out_4#0Matrix_1@2_out_4##1 out_4#0Matrix_1@2_out_4##2 8.083
C783 out_4#0Matrix_1@2_out_4##2 0 36.398fF
R531 out_4#0Matrix_1@2_out_4##2 out_4 8.083
R532 out_5 out_5##0 8.083
C784 out_5##0 0 36.398fF
R533 out_5##0 out_5##1 8.083
C785 out_5##1 0 36.398fF
R534 out_5##1 out_5##2 8.083
C786 out_5##2 0 36.398fF
R535 out_5##2 out_5#0Matrix_1@2_out_5 8.083
R536 out_6#0Matrix_1@2_out_6 out_6#0Matrix_1@2_out_6##0 8.083
C787 out_6#0Matrix_1@2_out_6##0 0 36.398fF
R537 out_6#0Matrix_1@2_out_6##0 out_6#0Matrix_1@2_out_6##1 8.083
C788 out_6#0Matrix_1@2_out_6##1 0 36.398fF
R538 out_6#0Matrix_1@2_out_6##1 out_6#0Matrix_1@2_out_6##2 8.083
C789 out_6#0Matrix_1@2_out_6##2 0 36.398fF
R539 out_6#0Matrix_1@2_out_6##2 out_6 8.083
R540 out_7 out_7##0 8.083
C790 out_7##0 0 36.398fF
R541 out_7##0 out_7##1 8.083
C791 out_7##1 0 36.398fF
R542 out_7##1 out_7##2 8.083
C792 out_7##2 0 36.398fF
R543 out_7##2 out_7#0Matrix_1@2_out_7 8.083
R544 out_8 out_8##0 8.083
C793 out_8##0 0 36.398fF
R545 out_8##0 out_8##1 8.083
C794 out_8##1 0 36.398fF
R546 out_8##1 out_8##2 8.083
C795 out_8##2 0 36.398fF
R547 out_8##2 out_8#0Matrix_1@2_out_8 8.083
R548 out_9#0Matrix_1@2_out_9 out_9#0Matrix_1@2_out_9##0 8.083
C796 out_9#0Matrix_1@2_out_9##0 0 36.398fF
R549 out_9#0Matrix_1@2_out_9##0 out_9#0Matrix_1@2_out_9##1 8.083
C797 out_9#0Matrix_1@2_out_9##1 0 36.398fF
R550 out_9#0Matrix_1@2_out_9##1 out_9#0Matrix_1@2_out_9##2 8.083
C798 out_9#0Matrix_1@2_out_9##2 0 36.398fF
R551 out_9#0Matrix_1@2_out_9##2 out_9 8.083
R552 out_10 out_10##0 8.083
C799 out_10##0 0 36.398fF
R553 out_10##0 out_10##1 8.083
C800 out_10##1 0 36.398fF
R554 out_10##1 out_10##2 8.083
C801 out_10##2 0 36.398fF
R555 out_10##2 out_10#0Matrix_1@2_out_10 8.083
R556 out_11#0Matrix_1@2_out_11 out_11#0Matrix_1@2_out_11##0 8.083
C802 out_11#0Matrix_1@2_out_11##0 0 36.398fF
R557 out_11#0Matrix_1@2_out_11##0 out_11#0Matrix_1@2_out_11##1 8.083
C803 out_11#0Matrix_1@2_out_11##1 0 36.398fF
R558 out_11#0Matrix_1@2_out_11##1 out_11#0Matrix_1@2_out_11##2 8.083
C804 out_11#0Matrix_1@2_out_11##2 0 36.398fF
R559 out_11#0Matrix_1@2_out_11##2 out_11 8.083
R560 out_12 out_12##0 8.083
C805 out_12##0 0 36.398fF
R561 out_12##0 out_12##1 8.083
C806 out_12##1 0 36.398fF
R562 out_12##1 out_12##2 8.083
C807 out_12##2 0 36.398fF
R563 out_12##2 out_12#0Matrix_1@2_out_12 8.083
R564 out_13#0Matrix_1@2_out_13 out_13#0Matrix_1@2_out_13##0 8.083
C808 out_13#0Matrix_1@2_out_13##0 0 36.398fF
R565 out_13#0Matrix_1@2_out_13##0 out_13#0Matrix_1@2_out_13##1 8.083
C809 out_13#0Matrix_1@2_out_13##1 0 36.398fF
R566 out_13#0Matrix_1@2_out_13##1 out_13#0Matrix_1@2_out_13##2 8.083
C810 out_13#0Matrix_1@2_out_13##2 0 36.398fF
R567 out_13#0Matrix_1@2_out_13##2 out_13 8.083
R568 out_14 out_14##0 8.083
C811 out_14##0 0 36.398fF
R569 out_14##0 out_14##1 8.083
C812 out_14##1 0 36.398fF
R570 out_14##1 out_14##2 8.083
C813 out_14##2 0 36.398fF
R571 out_14##2 out_14#0Matrix_1@2_out_14 8.083
R572 out_15#0Matrix_1@2_out_15 out_15#0Matrix_1@2_out_15##0 8.083
C814 out_15#0Matrix_1@2_out_15##0 0 36.398fF
R573 out_15#0Matrix_1@2_out_15##0 out_15#0Matrix_1@2_out_15##1 8.083
C815 out_15#0Matrix_1@2_out_15##1 0 36.398fF
R574 out_15#0Matrix_1@2_out_15##1 out_15#0Matrix_1@2_out_15##2 8.083
C816 out_15#0Matrix_1@2_out_15##2 0 36.398fF
R575 out_15#0Matrix_1@2_out_15##2 out_15 8.083
R576 out_16 out_16##0 8.083
C817 out_16##0 0 36.398fF
R577 out_16##0 out_16##1 8.083
C818 out_16##1 0 36.398fF
R578 out_16##1 out_16##2 8.083
C819 out_16##2 0 36.398fF
R579 out_16##2 out_16#0Matrix_1@2_out_16 8.083
R580 out_17#0Matrix_1@2_out_17 out_17#0Matrix_1@2_out_17##0 8.083
C820 out_17#0Matrix_1@2_out_17##0 0 36.398fF
R581 out_17#0Matrix_1@2_out_17##0 out_17#0Matrix_1@2_out_17##1 8.083
C821 out_17#0Matrix_1@2_out_17##1 0 36.398fF
R582 out_17#0Matrix_1@2_out_17##1 out_17#0Matrix_1@2_out_17##2 8.083
C822 out_17#0Matrix_1@2_out_17##2 0 36.398fF
R583 out_17#0Matrix_1@2_out_17##2 out_17 8.083
R584 out_18 out_18##0 8.083
C823 out_18##0 0 36.398fF
R585 out_18##0 out_18##1 8.083
C824 out_18##1 0 36.398fF
R586 out_18##1 out_18##2 8.083
C825 out_18##2 0 36.398fF
R587 out_18##2 out_18#0Matrix_1@2_out_18 8.083
R588 out_19#0Matrix_1@2_out_19 out_19#0Matrix_1@2_out_19##0 8.083
C826 out_19#0Matrix_1@2_out_19##0 0 36.398fF
R589 out_19#0Matrix_1@2_out_19##0 out_19#0Matrix_1@2_out_19##1 8.083
C827 out_19#0Matrix_1@2_out_19##1 0 36.398fF
R590 out_19#0Matrix_1@2_out_19##1 out_19#0Matrix_1@2_out_19##2 8.083
C828 out_19#0Matrix_1@2_out_19##2 0 36.398fF
R591 out_19#0Matrix_1@2_out_19##2 out_19 8.083
R592 out_20#0Matrix_1@2_out_20 out_20#0Matrix_1@2_out_20##0 8.083
C829 out_20#0Matrix_1@2_out_20##0 0 36.398fF
R593 out_20#0Matrix_1@2_out_20##0 out_20#0Matrix_1@2_out_20##1 8.083
C830 out_20#0Matrix_1@2_out_20##1 0 36.398fF
R594 out_20#0Matrix_1@2_out_20##1 out_20#0Matrix_1@2_out_20##2 8.083
C831 out_20#0Matrix_1@2_out_20##2 0 36.398fF
R595 out_20#0Matrix_1@2_out_20##2 out_20 8.083
R596 out_21 out_21##0 8.083
C832 out_21##0 0 36.398fF
R597 out_21##0 out_21##1 8.083
C833 out_21##1 0 36.398fF
R598 out_21##1 out_21##2 8.083
C834 out_21##2 0 36.398fF
R599 out_21##2 out_21#0Matrix_1@2_out_21 8.083
R600 out_22#0Matrix_1@2_out_22 out_22#0Matrix_1@2_out_22##0 8.083
C835 out_22#0Matrix_1@2_out_22##0 0 36.398fF
R601 out_22#0Matrix_1@2_out_22##0 out_22#0Matrix_1@2_out_22##1 8.083
C836 out_22#0Matrix_1@2_out_22##1 0 36.398fF
R602 out_22#0Matrix_1@2_out_22##1 out_22#0Matrix_1@2_out_22##2 8.083
C837 out_22#0Matrix_1@2_out_22##2 0 36.398fF
R603 out_22#0Matrix_1@2_out_22##2 out_22 8.083
R604 out_23 out_23##0 8.083
C838 out_23##0 0 36.398fF
R605 out_23##0 out_23##1 8.083
C839 out_23##1 0 36.398fF
R606 out_23##1 out_23##2 8.083
C840 out_23##2 0 36.398fF
R607 out_23##2 out_23#0Matrix_1@2_out_23 8.083
R608 out_24#0Matrix_1@2_out_24 out_24#0Matrix_1@2_out_24##0 8.083
C841 out_24#0Matrix_1@2_out_24##0 0 36.398fF
R609 out_24#0Matrix_1@2_out_24##0 out_24#0Matrix_1@2_out_24##1 8.083
C842 out_24#0Matrix_1@2_out_24##1 0 36.398fF
R610 out_24#0Matrix_1@2_out_24##1 out_24#0Matrix_1@2_out_24##2 8.083
C843 out_24#0Matrix_1@2_out_24##2 0 36.398fF
R611 out_24#0Matrix_1@2_out_24##2 out_24 8.083
R612 out_25 out_25##0 8.083
C844 out_25##0 0 36.398fF
R613 out_25##0 out_25##1 8.083
C845 out_25##1 0 36.398fF
R614 out_25##1 out_25##2 8.083
C846 out_25##2 0 36.398fF
R615 out_25##2 out_25#0Matrix_1@2_out_25 8.083
R616 out_26#0Matrix_1@2_out_26 out_26#0Matrix_1@2_out_26##0 8.083
C847 out_26#0Matrix_1@2_out_26##0 0 36.398fF
R617 out_26#0Matrix_1@2_out_26##0 out_26#0Matrix_1@2_out_26##1 8.083
C848 out_26#0Matrix_1@2_out_26##1 0 36.398fF
R618 out_26#0Matrix_1@2_out_26##1 out_26#0Matrix_1@2_out_26##2 8.083
C849 out_26#0Matrix_1@2_out_26##2 0 36.398fF
R619 out_26#0Matrix_1@2_out_26##2 out_26 8.083
R620 out_27 out_27##0 8.083
C850 out_27##0 0 36.398fF
R621 out_27##0 out_27##1 8.083
C851 out_27##1 0 36.398fF
R622 out_27##1 out_27##2 8.083
C852 out_27##2 0 36.398fF
R623 out_27##2 out_27#0Matrix_1@2_out_27 8.083
R624 out_28 out_28##0 8.083
C853 out_28##0 0 36.398fF
R625 out_28##0 out_28##1 8.083
C854 out_28##1 0 36.398fF
R626 out_28##1 out_28##2 8.083
C855 out_28##2 0 36.398fF
R627 out_28##2 out_28#0Matrix_1@2_out_28 8.083
R628 out_29#0Matrix_1@2_out_29 out_29#0Matrix_1@2_out_29##0 8.083
C856 out_29#0Matrix_1@2_out_29##0 0 36.398fF
R629 out_29#0Matrix_1@2_out_29##0 out_29#0Matrix_1@2_out_29##1 8.083
C857 out_29#0Matrix_1@2_out_29##1 0 36.398fF
R630 out_29#0Matrix_1@2_out_29##1 out_29#0Matrix_1@2_out_29##2 8.083
C858 out_29#0Matrix_1@2_out_29##2 0 36.398fF
R631 out_29#0Matrix_1@2_out_29##2 out_29 8.083
R632 out_30 out_30##0 8.083
C859 out_30##0 0 36.398fF
R633 out_30##0 out_30##1 8.083
C860 out_30##1 0 36.398fF
R634 out_30##1 out_30##2 8.083
C861 out_30##2 0 36.398fF
R635 out_30##2 out_30#0Matrix_1@2_out_30 8.083
R636 out_31#0Matrix_1@2_out_31 out_31#0Matrix_1@2_out_31##0 8.083
C862 out_31#0Matrix_1@2_out_31##0 0 36.398fF
R637 out_31#0Matrix_1@2_out_31##0 out_31#0Matrix_1@2_out_31##1 8.083
C863 out_31#0Matrix_1@2_out_31##1 0 36.398fF
R638 out_31#0Matrix_1@2_out_31##1 out_31#0Matrix_1@2_out_31##2 8.083
C864 out_31#0Matrix_1@2_out_31##2 0 36.398fF
R639 out_31#0Matrix_1@2_out_31##2 out_31 8.083
R640 out_32 out_32##0 8.083
C865 out_32##0 0 36.398fF
R641 out_32##0 out_32##1 8.083
C866 out_32##1 0 36.398fF
R642 out_32##1 out_32##2 8.083
C867 out_32##2 0 36.398fF
R643 out_32##2 out_32#0Matrix_1@3_out_0 8.083
R644 out_33#0Matrix_1@3_out_1 out_33#0Matrix_1@3_out_1##0 8.083
C868 out_33#0Matrix_1@3_out_1##0 0 36.398fF
R645 out_33#0Matrix_1@3_out_1##0 out_33#0Matrix_1@3_out_1##1 8.083
C869 out_33#0Matrix_1@3_out_1##1 0 36.398fF
R646 out_33#0Matrix_1@3_out_1##1 out_33#0Matrix_1@3_out_1##2 8.083
C870 out_33#0Matrix_1@3_out_1##2 0 36.398fF
R647 out_33#0Matrix_1@3_out_1##2 out_33 8.083
R648 out_34 out_34##0 8.083
C871 out_34##0 0 36.398fF
R649 out_34##0 out_34##1 8.083
C872 out_34##1 0 36.398fF
R650 out_34##1 out_34##2 8.083
C873 out_34##2 0 36.398fF
R651 out_34##2 out_34#0Matrix_1@3_out_2 8.083
R652 out_35#0Matrix_1@3_out_3 out_35#0Matrix_1@3_out_3##0 8.083
C874 out_35#0Matrix_1@3_out_3##0 0 36.398fF
R653 out_35#0Matrix_1@3_out_3##0 out_35#0Matrix_1@3_out_3##1 8.083
C875 out_35#0Matrix_1@3_out_3##1 0 36.398fF
R654 out_35#0Matrix_1@3_out_3##1 out_35#0Matrix_1@3_out_3##2 8.083
C876 out_35#0Matrix_1@3_out_3##2 0 36.398fF
R655 out_35#0Matrix_1@3_out_3##2 out_35 8.083
R656 out_36 out_36##0 8.083
C877 out_36##0 0 36.398fF
R657 out_36##0 out_36##1 8.083
C878 out_36##1 0 36.398fF
R658 out_36##1 out_36##2 8.083
C879 out_36##2 0 36.398fF
R659 out_36##2 out_36#0Matrix_1@3_out_4 8.083
R660 out_37#0Matrix_1@3_out_5 out_37#0Matrix_1@3_out_5##0 8.083
C880 out_37#0Matrix_1@3_out_5##0 0 36.398fF
R661 out_37#0Matrix_1@3_out_5##0 out_37#0Matrix_1@3_out_5##1 8.083
C881 out_37#0Matrix_1@3_out_5##1 0 36.398fF
R662 out_37#0Matrix_1@3_out_5##1 out_37#0Matrix_1@3_out_5##2 8.083
C882 out_37#0Matrix_1@3_out_5##2 0 36.398fF
R663 out_37#0Matrix_1@3_out_5##2 out_37 8.083
R664 out_38 out_38##0 8.083
C883 out_38##0 0 36.398fF
R665 out_38##0 out_38##1 8.083
C884 out_38##1 0 36.398fF
R666 out_38##1 out_38##2 8.083
C885 out_38##2 0 36.398fF
R667 out_38##2 out_38#0Matrix_1@3_out_6 8.083
R668 out_39#0Matrix_1@3_out_7 out_39#0Matrix_1@3_out_7##0 8.083
C886 out_39#0Matrix_1@3_out_7##0 0 36.398fF
R669 out_39#0Matrix_1@3_out_7##0 out_39#0Matrix_1@3_out_7##1 8.083
C887 out_39#0Matrix_1@3_out_7##1 0 36.398fF
R670 out_39#0Matrix_1@3_out_7##1 out_39#0Matrix_1@3_out_7##2 8.083
C888 out_39#0Matrix_1@3_out_7##2 0 36.398fF
R671 out_39#0Matrix_1@3_out_7##2 out_39 8.083
R672 out_40 out_40##0 8.083
C889 out_40##0 0 36.398fF
R673 out_40##0 out_40##1 8.083
C890 out_40##1 0 36.398fF
R674 out_40##1 out_40##2 8.083
C891 out_40##2 0 36.398fF
R675 out_40##2 out_40#0Matrix_1@3_out_8 8.083
R676 out_41#0Matrix_1@3_out_9 out_41#0Matrix_1@3_out_9##0 8.083
C892 out_41#0Matrix_1@3_out_9##0 0 36.398fF
R677 out_41#0Matrix_1@3_out_9##0 out_41#0Matrix_1@3_out_9##1 8.083
C893 out_41#0Matrix_1@3_out_9##1 0 36.398fF
R678 out_41#0Matrix_1@3_out_9##1 out_41#0Matrix_1@3_out_9##2 8.083
C894 out_41#0Matrix_1@3_out_9##2 0 36.398fF
R679 out_41#0Matrix_1@3_out_9##2 out_41 8.083
R680 out_42 out_42##0 8.083
C895 out_42##0 0 36.398fF
R681 out_42##0 out_42##1 8.083
C896 out_42##1 0 36.398fF
R682 out_42##1 out_42##2 8.083
C897 out_42##2 0 36.398fF
R683 out_42##2 out_42#0Matrix_1@3_out_10 8.083
R684 out_43#0Matrix_1@3_out_11 out_43#0Matrix_1@3_out_11##0 8.083
C898 out_43#0Matrix_1@3_out_11##0 0 36.398fF
R685 out_43#0Matrix_1@3_out_11##0 out_43#0Matrix_1@3_out_11##1 8.083
C899 out_43#0Matrix_1@3_out_11##1 0 36.398fF
R686 out_43#0Matrix_1@3_out_11##1 out_43#0Matrix_1@3_out_11##2 8.083
C900 out_43#0Matrix_1@3_out_11##2 0 36.398fF
R687 out_43#0Matrix_1@3_out_11##2 out_43 8.083
R688 out_44 out_44##0 8.083
C901 out_44##0 0 36.398fF
R689 out_44##0 out_44##1 8.083
C902 out_44##1 0 36.398fF
R690 out_44##1 out_44##2 8.083
C903 out_44##2 0 36.398fF
R691 out_44##2 out_44#0Matrix_1@3_out_12 8.083
R692 out_45#0Matrix_1@3_out_13 out_45#0Matrix_1@3_out_13##0 8.083
C904 out_45#0Matrix_1@3_out_13##0 0 36.398fF
R693 out_45#0Matrix_1@3_out_13##0 out_45#0Matrix_1@3_out_13##1 8.083
C905 out_45#0Matrix_1@3_out_13##1 0 36.398fF
R694 out_45#0Matrix_1@3_out_13##1 out_45#0Matrix_1@3_out_13##2 8.083
C906 out_45#0Matrix_1@3_out_13##2 0 36.398fF
R695 out_45#0Matrix_1@3_out_13##2 out_45 8.083
R696 out_46 out_46##0 8.083
C907 out_46##0 0 36.398fF
R697 out_46##0 out_46##1 8.083
C908 out_46##1 0 36.398fF
R698 out_46##1 out_46##2 8.083
C909 out_46##2 0 36.398fF
R699 out_46##2 out_46#0Matrix_1@3_out_14 8.083
R700 out_47#0Matrix_1@3_out_15 out_47#0Matrix_1@3_out_15##0 8.083
C910 out_47#0Matrix_1@3_out_15##0 0 36.398fF
R701 out_47#0Matrix_1@3_out_15##0 out_47#0Matrix_1@3_out_15##1 8.083
C911 out_47#0Matrix_1@3_out_15##1 0 36.398fF
R702 out_47#0Matrix_1@3_out_15##1 out_47#0Matrix_1@3_out_15##2 8.083
C912 out_47#0Matrix_1@3_out_15##2 0 36.398fF
R703 out_47#0Matrix_1@3_out_15##2 out_47 8.083
R704 out_48 out_48##0 8.083
C913 out_48##0 0 36.398fF
R705 out_48##0 out_48##1 8.083
C914 out_48##1 0 36.398fF
R706 out_48##1 out_48##2 8.083
C915 out_48##2 0 36.398fF
R707 out_48##2 out_48#0Matrix_1@3_out_16 8.083
R708 out_49#0Matrix_1@3_out_17 out_49#0Matrix_1@3_out_17##0 8.083
C916 out_49#0Matrix_1@3_out_17##0 0 36.398fF
R709 out_49#0Matrix_1@3_out_17##0 out_49#0Matrix_1@3_out_17##1 8.083
C917 out_49#0Matrix_1@3_out_17##1 0 36.398fF
R710 out_49#0Matrix_1@3_out_17##1 out_49#0Matrix_1@3_out_17##2 8.083
C918 out_49#0Matrix_1@3_out_17##2 0 36.398fF
R711 out_49#0Matrix_1@3_out_17##2 out_49 8.083
R712 out_50#0Matrix_1@3_out_18 out_50#0Matrix_1@3_out_18##0 8.083
C919 out_50#0Matrix_1@3_out_18##0 0 36.398fF
R713 out_50#0Matrix_1@3_out_18##0 out_50#0Matrix_1@3_out_18##1 8.083
C920 out_50#0Matrix_1@3_out_18##1 0 36.398fF
R714 out_50#0Matrix_1@3_out_18##1 out_50#0Matrix_1@3_out_18##2 8.083
C921 out_50#0Matrix_1@3_out_18##2 0 36.398fF
R715 out_50#0Matrix_1@3_out_18##2 out_50 8.083
R716 out_51 out_51##0 8.083
C922 out_51##0 0 36.398fF
R717 out_51##0 out_51##1 8.083
C923 out_51##1 0 36.398fF
R718 out_51##1 out_51##2 8.083
C924 out_51##2 0 36.398fF
R719 out_51##2 out_51#0Matrix_1@3_out_19 8.083
R720 out_52#0Matrix_1@3_out_20 out_52#0Matrix_1@3_out_20##0 8.083
C925 out_52#0Matrix_1@3_out_20##0 0 36.398fF
R721 out_52#0Matrix_1@3_out_20##0 out_52#0Matrix_1@3_out_20##1 8.083
C926 out_52#0Matrix_1@3_out_20##1 0 36.398fF
R722 out_52#0Matrix_1@3_out_20##1 out_52#0Matrix_1@3_out_20##2 8.083
C927 out_52#0Matrix_1@3_out_20##2 0 36.398fF
R723 out_52#0Matrix_1@3_out_20##2 out_52 8.083
R724 out_53 out_53##0 8.083
C928 out_53##0 0 36.398fF
R725 out_53##0 out_53##1 8.083
C929 out_53##1 0 36.398fF
R726 out_53##1 out_53##2 8.083
C930 out_53##2 0 36.398fF
R727 out_53##2 out_53#0Matrix_1@3_out_21 8.083
R728 out_54#0Matrix_1@3_out_22 out_54#0Matrix_1@3_out_22##0 8.083
C931 out_54#0Matrix_1@3_out_22##0 0 36.398fF
R729 out_54#0Matrix_1@3_out_22##0 out_54#0Matrix_1@3_out_22##1 8.083
C932 out_54#0Matrix_1@3_out_22##1 0 36.398fF
R730 out_54#0Matrix_1@3_out_22##1 out_54#0Matrix_1@3_out_22##2 8.083
C933 out_54#0Matrix_1@3_out_22##2 0 36.398fF
R731 out_54#0Matrix_1@3_out_22##2 out_54 8.083
R732 out_55 out_55##0 8.083
C934 out_55##0 0 36.398fF
R733 out_55##0 out_55##1 8.083
C935 out_55##1 0 36.398fF
R734 out_55##1 out_55##2 8.083
C936 out_55##2 0 36.398fF
R735 out_55##2 out_55#0Matrix_1@3_out_23 8.083
R736 out_56#0Matrix_1@3_out_24 out_56#0Matrix_1@3_out_24##0 8.083
C937 out_56#0Matrix_1@3_out_24##0 0 36.398fF
R737 out_56#0Matrix_1@3_out_24##0 out_56#0Matrix_1@3_out_24##1 8.083
C938 out_56#0Matrix_1@3_out_24##1 0 36.398fF
R738 out_56#0Matrix_1@3_out_24##1 out_56#0Matrix_1@3_out_24##2 8.083
C939 out_56#0Matrix_1@3_out_24##2 0 36.398fF
R739 out_56#0Matrix_1@3_out_24##2 out_56 8.083
R740 out_57 out_57##0 8.083
C940 out_57##0 0 36.398fF
R741 out_57##0 out_57##1 8.083
C941 out_57##1 0 36.398fF
R742 out_57##1 out_57##2 8.083
C942 out_57##2 0 36.398fF
R743 out_57##2 out_57#0Matrix_1@3_out_25 8.083
R744 out_58#0Matrix_1@3_out_26 out_58#0Matrix_1@3_out_26##0 8.083
C943 out_58#0Matrix_1@3_out_26##0 0 36.398fF
R745 out_58#0Matrix_1@3_out_26##0 out_58#0Matrix_1@3_out_26##1 8.083
C944 out_58#0Matrix_1@3_out_26##1 0 36.398fF
R746 out_58#0Matrix_1@3_out_26##1 out_58#0Matrix_1@3_out_26##2 8.083
C945 out_58#0Matrix_1@3_out_26##2 0 36.398fF
R747 out_58#0Matrix_1@3_out_26##2 out_58 8.083
R748 out_59 out_59##0 8.083
C946 out_59##0 0 36.398fF
R749 out_59##0 out_59##1 8.083
C947 out_59##1 0 36.398fF
R750 out_59##1 out_59##2 8.083
C948 out_59##2 0 36.398fF
R751 out_59##2 out_59#0Matrix_1@3_out_27 8.083
R752 out_60#0Matrix_1@3_out_28 out_60#0Matrix_1@3_out_28##0 8.083
C949 out_60#0Matrix_1@3_out_28##0 0 36.398fF
R753 out_60#0Matrix_1@3_out_28##0 out_60#0Matrix_1@3_out_28##1 8.083
C950 out_60#0Matrix_1@3_out_28##1 0 36.398fF
R754 out_60#0Matrix_1@3_out_28##1 out_60#0Matrix_1@3_out_28##2 8.083
C951 out_60#0Matrix_1@3_out_28##2 0 36.398fF
R755 out_60#0Matrix_1@3_out_28##2 out_60 8.083
R756 out_61 out_61##0 8.083
C952 out_61##0 0 36.398fF
R757 out_61##0 out_61##1 8.083
C953 out_61##1 0 36.398fF
R758 out_61##1 out_61##2 8.083
C954 out_61##2 0 36.398fF
R759 out_61##2 out_61#0Matrix_1@3_out_29 8.083
R760 out_62#0Matrix_1@3_out_30 out_62#0Matrix_1@3_out_30##0 8.083
C955 out_62#0Matrix_1@3_out_30##0 0 36.398fF
R761 out_62#0Matrix_1@3_out_30##0 out_62#0Matrix_1@3_out_30##1 8.083
C956 out_62#0Matrix_1@3_out_30##1 0 36.398fF
R762 out_62#0Matrix_1@3_out_30##1 out_62#0Matrix_1@3_out_30##2 8.083
C957 out_62#0Matrix_1@3_out_30##2 0 36.398fF
R763 out_62#0Matrix_1@3_out_30##2 out_62 8.083
R764 out_63 out_63##0 8.083
C958 out_63##0 0 36.398fF
R765 out_63##0 out_63##1 8.083
C959 out_63##1 0 36.398fF
R766 out_63##1 out_63##2 8.083
C960 out_63##2 0 36.398fF
R767 out_63##2 out_63#0Matrix_1@3_out_31 8.083
R768 out_0#1pixelv3@0_out out_0#1pixelv3@0_out##0 9.228
C961 out_0#1pixelv3@0_out##0 0 45.449fF
R769 out_0#1pixelv3@0_out##0 out_0#1pixelv3@0_out##1 9.228
C962 out_0#1pixelv3@0_out##1 0 45.449fF
R770 out_0#1pixelv3@0_out##1 out_0#1pixelv3@0_out##2 9.228
C963 out_0#1pixelv3@0_out##2 0 45.449fF
R771 out_0#1pixelv3@0_out##2 out_0#1pixelv3@0_out##3 9.228
C964 out_0#1pixelv3@0_out##3 0 45.449fF
R772 out_0#1pixelv3@0_out##3 out_0#1pixelv3@0_out##4 9.228
C965 out_0#1pixelv3@0_out##4 0 45.449fF
R773 out_0#1pixelv3@0_out##4 out_0#1pixelv3@0_out##5 9.228
C966 out_0#1pixelv3@0_out##5 0 45.449fF
R774 out_0#1pixelv3@0_out##5 out_0 9.228

* Spice Code nodes in cell cell 'Simulacion_Matrix_4096{lay}'
D1 gnd FD photodiode
I1 FD 0 300p
I2 out_0 0 5.7u
V1 vdd_reset 0 5
V2 vdd 0 5
V3 gnd 0 0
V4 reset 0 PULSE(0 5 0 1p 1p 5u 100u 4)
V5 select 0 PULSE(0 5 90u 1p 1p 5u 100u 4)
.model photodiode D (IS = 50f CJO=6.3f  VJ= 0.636 M = 0.33)
.tran 100u
.include G:\Mi unidad\Universidad\Semestre Actual\CMOS Image Sensor\Layout\C5_models.txt
.END
